options:
  parameters:
    author: Juan Gerez Jimenez
    generate_options: qt_gui
    id: receptor
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fft_size
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: |-
      Guarda la secuencia de bits resultante 
      en un archivo o enviarla a algún otro proceso.
    type: byte
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    comment: |-
      El prefijo cíclico (CP) se añade en el transmisor 
      para evitar interferencia entre símbolos. Aquí, quitamos
      esas muestras extra. Al final, quedamos con un vector 
      de longitud fft_size.
    m: '1'
    n: '2'
    offset: '0'
    type: complex
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    comment: |-
      Realiza una corrección gruesa de frecuencia
       si se sabe que hay un offset grande entre 
      transmisor y receptor.
    phase_inc: '0.0'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    comment: |-
      Agrupa las muestras en bloques 
      (vectores) de cierto tamaño
    type: complex
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: |-
      Mapea cada símbolo complejo a bits según la 
      constelación QPSK. De esta manera, saca la 
      secuencia binaria.
  states: {}
- name: digital_ofdm_frame_equalizer_vcvc_0
  id: digital_ofdm_frame_equalizer_vcvc
  parameters:
    comment: |-
      Buscar ofdm_equalizer_simpledfe

      Realiza estimación de canal usando subportadoras 
      piloto y corrige amplitud/fase en cada subportadora.
      Te devuelve un vector con las subportadoras ya 
      “limpias” para demodular.
    cp_len: fft_len/4
    fft_len: fft_len
    propagate_channel_state: 'True'
  states: {}
- name: dtv_dvbt_reed_solomon_dec_0
  id: dtv_dvbt_reed_solomon_dec
  parameters:
    blocks: '8'
    comment: |-
      para CRC32. 
      Este bloque comprueba (o recupera) la información 
      y filtra los paquetes inválidos.
    gfpoly: '0x11d'
    k: '239'
    m: '8'
    n: '255'
    p: '2'
    s: '51'
    t: '8'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    comment: |-
      Convierte el símbolo OFDM del dominio del 
      tiempo al dominio de frecuencias.
    fft_size: fft_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(1024)
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: '0'
    comment: |-
      Este bloque obtiene muestras complejas
       que llegan desde el hardware
    gain0: '0'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_keep_m_in_n_0, '0', fft_vxx_0, '0']
- [blocks_rotator_cc_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_keep_m_in_n_0, '0']
- [digital_constellation_decoder_cb_0, '0', dtv_dvbt_reed_solomon_dec_0, '0']
- [digital_ofdm_frame_equalizer_vcvc_0, '0', digital_constellation_decoder_cb_0, '0']
- [dtv_dvbt_reed_solomon_dec_0, '0', blocks_file_sink_0, '0']
- [fft_vxx_0, '0', digital_ofdm_frame_equalizer_vcvc_0, '0']
- [uhd_usrp_source_0, '0', blocks_rotator_cc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
