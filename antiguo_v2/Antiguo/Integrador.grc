options:
  parameters:
    author: Gerez
    category: Custom
    comment: https://wiki.gnuradio.org/index.php?title=QPSK_Mod_and_Demod
    generate_options: qt_gui
    id: transmisor
    output_language: python
    title: transmisor
  states: {}

blocks:
- name: const
  id: variable_constellation
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freq_offset
  id: variable
  parameters:
    comment: |-
      0.001----32HZ-----por usar samp_rate
      portadora hackRF 915 MHz
    value: '0.001'
  states: {}
- name: nfiltros
  id: variable
  parameters:
    value: '64'
  states: {}
- name: noise_amp
  id: variable
  parameters:
    comment: 0.071 ----SNR=20dB
    value: '0.0'
  states: {}
- name: polyphase_num_filters
  id: variable
  parameters:
    value: '32'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[1+1j, -1+1j, -1-1j, 1-1j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {state: disabled}
- name: rrc_1
  id: variable_rrc_filter_taps
  parameters:
    alpha: '0.35'
    gain: nfiltros
    ntaps: 11*sps*nfiltros
    samp_rate: nfiltros*sps
    sym_rate: '1'
  states: {}
- name: rrc_polyphase
  id: variable_rrc_filter_taps
  parameters:
    alpha: '0.35'
    gain: sps
    ntaps: 11*polyphase_num_filters*sps
    samp_rate: sps
    sym_rate: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '1024'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '0'
    type: byte
  states: {state: disabled}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '2'
    l: '8'
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    comment: segmenta en paquetes etiquetados.
    len_tag_key: '"packet_len"'
    packet_len: '128'
    type: byte
  states: {state: bypassed}
- name: blocks_stream_to_tagged_stream_1
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '128'
    type: byte
  states: {state: disabled}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.001'
    freq_offset: freq_offset*10
    noise_voltage: noise_amp
    seed: '0'
    taps: '1.0'
  states: {state: bypassed}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: const
  states: {state: disabled}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: const
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '01010101010101010101010101010101'
    tagname: '"packet_len"'
    threshold: '1'
    type: byte
  states: {state: disabled}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: '0.01'
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    comment: |-
      agrega CRC basado en la longitud 
      de los paquetes etiquetados.
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {state: bypassed}
- name: digital_crc32_bb_1
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {state: disabled}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: 11*sps
    rolloff: '.35'
    samps_per_sym: sps
    type: cc
    w: '.1'
  states: {}
- name: digital_packet_headergenerator_bb_0
  id: digital_packet_headergenerator_bb
  parameters:
    header_formatter: |
      digital.packet_header_default(32, "packet_len")
    len_tag_key: '"packet_len"'
  states: {state: disabled}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfiltros
    init_phase: nfiltros//2
    loop_bw: '.01'
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rrc_1
    type: ccf
  states: {}
- name: fec_ber_bf_0
  id: fec_ber_bf
  parameters:
    test_mode: 'False'
  states: {state: disabled}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    name: '"CANAL"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1_0
  id: qtgui_const_sink_x
  parameters:
    name: '"Luego_Costas"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1_0_0
  id: qtgui_const_sink_x
  parameters:
    name: '"POLY. SYNC."'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    min: '0'
    name: '"BER_visual"'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"despues"'
    size: '500'
    srate: '1'
    type: float
  states: {state: disabled}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: excess_bw
    decim: '1'
    gain: '1'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: fir_filter_ccf
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: entrada_rx
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: entrada_rx
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_delay_0, '0', fec_ber_bf_0, '1']
- [blocks_repack_bits_bb_0, '0', blocks_stream_to_tagged_stream_1, '0']
- [blocks_repack_bits_bb_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_delay_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_crc32_bb_0, '0']
- [blocks_stream_to_tagged_stream_1, '0', digital_crc32_bb_1, '0']
- [channels_channel_model_0, '0', qtgui_const_sink_x_1, '0']
- [channels_channel_model_0, '0', virtual_sink_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_constellation_encoder_bc_0, '0', channels_channel_model_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_stream_to_tagged_stream_1, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_1_0, '0']
- [digital_crc32_bb_0, '0', digital_constellation_encoder_bc_0, '0']
- [digital_crc32_bb_0, '0', digital_packet_headergenerator_bb_0, '0']
- [digital_crc32_bb_1, '0', blocks_char_to_float_0_0, '0']
- [digital_crc32_bb_1, '0', fec_ber_bf_0, '0']
- [digital_fll_band_edge_cc_0, '0', root_raised_cosine_filter_0, '0']
- [digital_packet_headergenerator_bb_0, '0', digital_constellation_encoder_bc_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', qtgui_const_sink_x_1_0_0, '0']
- [fec_ber_bf_0, '0', qtgui_number_sink_0, '0']
- [root_raised_cosine_filter_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [virtual_source_0, '0', digital_fll_band_edge_cc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
