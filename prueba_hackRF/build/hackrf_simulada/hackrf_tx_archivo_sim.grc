options:
  parameters:
    author: Juan Gerez
    comment: |-
      Opciones del flowgraph: título de la ventana,
      interfaz QT GUI y nombre del programa que arma
      GRC al apretar F6 (hackrf_tx_archivo.py, en
      esta misma carpeta).
    description: 'VERSIÓN SIMULADA de grc_hackrf/hackrf_tx_archivo.grc (la genera hackrf_simulada/generar_grc_simulados.py): en lugar de una HackRF usa emulador_hackrf.py. Transmite un archivo en paquetes numerados (CRC-32, preámbulo y longitud) con 4-QAM diferencial por un HackRF; solo bloques estándar de GNU Radio'
    generate_options: qt_gui
    id: hackrf_tx_archivo_sim
    output_language: python
    title: '[SIMULADA] HackRF TX: transmisión de un archivo (4-QAM, bloques estándar)'
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    comment: |-
      Bytes del archivo en cada paquete. Tiene que
      ser el mismo número en el receptor.
    value: '200'
  states: {}
- name: W
  id: variable
  parameters:
    comment: |-
      Bytes de relleno al azar al comienzo de cada
      pasada (2500 bytes = 40 ms): le dan tiempo al
      receptor para engancharse.
    value: '2500'
  states: {}
- name: amp_tx
  id: variable_qtgui_check_box
  parameters:
    comment: |-
      Casilla de la ventana: prende el amplificador
      extra del TX (+14 dB). Empezar con la casilla
      apagada; nunca prenderla con un cable sin
      atenuador.
    'false': 'False'
    gui_hint: 0,2,1,1
    label: Amplificador TX (+14 dB)
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: amplitud
  id: variable_qtgui_range
  parameters:
    comment: |-
      Control de la ventana: número por el que se
      multiplica la señal antes de la HackRF. Los
      picos de I y Q tienen que quedar debajo de 1:
      usar 0,6 como máximo.
    gui_hint: 0,3,1,1
    label: Amplitud digital (pico < 1)
    min_len: '150'
    start: '0.05'
    step: '0.05'
    stop: '0.7'
    value: '0.5'
  states: {}
- name: bytes_pasada
  id: variable
  parameters:
    comment: 'Bytes de una pasada: relleno W + n_paq tramas.'
    value: W + n_paq * bytes_trama
  states: {}
- name: bytes_trama
  id: variable
  parameters:
    comment: |-
      Bytes de cada trama: preámbulo 8 + longitud 4
      + número 2 + datos N + CRC 4 = N + 18.
    value: N + 18
  states: {}
- name: contenido
  id: variable
  parameters:
    comment: |-
      Bytes del archivo, como lista de números de 0
      a 255 (se lee entero al abrir el flowgraph).
      Si no existe: el texto "No se encontro el
      archivo ...".
    value: list(open(archivo, "rb").read()) if encontrado else list(("No se encontro el archivo " + archivo).encode())
  states: {}
- name: datos
  id: variable
  parameters:
    comment: |-
      Datos de una pasada: el archivo (completado
      con ceros hasta llenar el último paquete) + el
      paquete de descripción. Son n_paq × N bytes.
    value: contenido + [0] * (n_datos * N - len(contenido)) + (descripcion + [0] * N)[:N]
  states: {}
- name: descripcion
  id: variable
  parameters:
    comment: |-
      Contenido del último paquete de cada pasada:
      ARCHIVO|nombre (hasta 40
      bytes)|tamaño|N|paquetes|huella|. Con él,
      reconstruir_archivo.py sabe cómo armar el
      archivo.
    value: list(b"ARCHIVO|" + nombre.encode()[:40] + ("|%d|%d|%d|%s|" % (len(contenido), N, n_paq, huella)).encode())
  states: {}
- name: dispositivo
  id: variable
  parameters:
    comment: |-
      Qué HackRF usar: "serial=..." (el número lo
      muestra hackrf_info). Vacío = la primera que
      encuentre.
    value: '"0000000000000000308066e62215484b"'
  states: {}
- name: duracion_pasada
  id: variable
  parameters:
    comment: |-
      Segundos que dura una pasada en el aire (8
      bits por byte, 2 bits por símbolo, 250 000
      símbolos/s).
    value: bytes_pasada * 8 / 2 / (samp_rate / sps)
  states: {}
- name: encontrado
  id: variable
  parameters:
    comment: |-
      True si el archivo existe. Si no existe, en su
      lugar se manda un texto de aviso.
    value: os.path.isfile(archivo)
  states: {}
- name: enviados
  id: variable_function_probe
  parameters:
    block_id: limite
    comment: |-
      Lee 2 veces por segundo cuántos bytes ya
      salieron del bloque "limite" (Head), con su
      función nitems_written. Con eso se cuentan las
      pasadas.
    function_args: '0'
    function_name: nitems_written
    poll_rate: '2'
    value: '0'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    comment: |-
      Roll-off del filtro RRC (0,35): cuánto más
      ancho que el mínimo es el espectro. La señal
      ocupa 250 k × 1,35 ≈ 340 kHz.
    value: '0.35'
  states: {}
- name: f_offset
  id: variable
  parameters:
    comment: |-
      Corrimiento digital de 400 kHz: la HackRF se
      sintoniza 400 kHz más abajo y la señal se
      corre +400 kHz. Así el pico que deja la placa
      en el centro del espectro queda fuera de la
      señal.
    value: 400e3
  states: {}
- name: formato_trama
  id: variable_header_format_default
  parameters:
    access_code: '0'
    bps: '1'
    comment: |-
      Formato del encabezado de cada trama:
      preámbulo de 64 bits (Access Code 0 = el
      preámbulo estándar de GNU Radio) + longitud
      del paquete en 16 bits, escrita 2 veces. Lo
      usa el Protocol Formatter.
    threshold: '0'
  states: {}
- name: freq_mhz
  id: variable_qtgui_entry
  parameters:
    comment: |-
      Casilla de la ventana: frecuencia de la
      portadora en MHz. Se aplica al apretar Enter.
      La HackRF se sintoniza en esta frecuencia -
      400 kHz (ver f_offset).
    gui_hint: 0,0,1,1
    label: Frecuencia [MHz]
    type: real
    value: '915'
  states: {}
- name: huella
  id: variable
  parameters:
    comment: |-
      Huella SHA-256 del archivo (64 caracteres): el
      receptor la usa para comprobar que el archivo
      llegó idéntico.
    value: hashlib.sha256(bytes(contenido)).hexdigest()
  states: {}
- name: lbl_archivo
  id: variable_qtgui_label
  parameters:
    comment: |-
      Muestra en la ventana el nombre y el tamaño
      del archivo que se transmite.
    gui_hint: 1,0,1,1
    label: 'Archivo: '
    type: string
    value: '"%s (%d bytes)" % (nombre, len(contenido))'
  states: {}
- name: lbl_huella
  id: variable_qtgui_label
  parameters:
    comment: |-
      Muestra en la ventana el comienzo de la huella
      SHA-256 del archivo.
    gui_hint: 1,2,1,1
    label: 'SHA-256: '
    type: string
    value: huella[:16] + "..."
  states: {}
- name: lbl_paquetes
  id: variable_qtgui_label
  parameters:
    comment: |-
      Muestra en la ventana cuántos paquetes tiene
      cada pasada y cuántos segundos dura.
    gui_hint: 1,1,1,1
    label: 'Paquetes por pasada: '
    type: string
    value: '"%d (%.2f s cada pasada)" % (n_paq, duracion_pasada)'
  states: {}
- name: lbl_pasadas
  id: variable_qtgui_label
  parameters:
    comment: |-
      Muestra en la ventana cuántas pasadas ya se
      mandaron (bytes que salieron / bytes por
      pasada). Va unos 0,5 s adelantado: hay
      muestras esperando en los buffers.
    formatter: 'lambda x: ''%.2f'' % x'
    gui_hint: 1,3,1,1
    label: 'Pasadas enviadas: '
    type: real
    value: min(enviados, total_bytes - W) / bytes_pasada
  states: {}
- name: n_datos
  id: variable
  parameters:
    comment: |-
      Cuántos paquetes de N bytes hacen falta para
      el archivo (redondeando hacia arriba).
    value: (len(contenido) + N - 1) // N
  states: {}
- name: n_paq
  id: variable
  parameters:
    comment: |-
      Paquetes por pasada: los de datos + 1 final
      que describe el archivo (nombre, tamaño y
      huella).
    value: n_datos + 1
  states: {}
- name: nombre
  id: variable
  parameters:
    comment: |-
      Nombre del archivo sin la carpeta (viaja en el
      último paquete). Si no existe:
      ERROR_archivo_no_encontrado.txt
    value: os.path.basename(archivo) if encontrado else "ERROR_archivo_no_encontrado.txt"
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    comment: |-
      Constelación 4-QAM: 4 puntos (±0,707 ± j0,707)
      con código Gray (Symbol Map 0, 1, 3, 2: los
      vecinos difieren en un solo bit). La usa el
      modulador.
    const_points: '[-0.707-0.707j, 0.707-0.707j, +0.707+0.707j, -0.707+0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: relleno
  id: variable
  parameters:
    comment: |-
      W bytes al azar (siempre los mismos: semilla
      1). No llevan preámbulo, así que el receptor
      no los toma como tramas.
    value: list(random.Random(1).randbytes(W))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      Muestreo: 2 M muestras por segundo (2 MHz de
      banda). Lo usan la HackRF, el Rotator y los
      gráficos. 2 M es lo mínimo recomendado para la
      HackRF.
    value: 2e6
  states: {}
- name: secuencia
  id: variable
  parameters:
    comment: |-
      Números de paquete de una pasada: 0, 1, 2, ...
      n_paq - 1, cada uno en 2 bytes (primero el
      byte alto).
    value: '[b for i in range(n_paq) for b in ((i // 256) % 256, i % 256)]'
  states: {}
- name: sps
  id: variable
  parameters:
    comment: |-
      Muestras por símbolo en el TX. 2 M / 8 = 250
      000 símbolos/s; con 2 bits por símbolo son 500
      kbit/s.
    value: '8'
  states: {}
- name: total_bytes
  id: variable
  parameters:
    comment: |-
      Bytes que deja pasar el Head: "repeticiones"
      pasadas + un relleno final (para que la última
      trama salga entera). Con repeticiones = 0 no
      hay límite (2^62).
    value: repeticiones * bytes_pasada + W if repeticiones > 0 else 2**62
  states: {}
- name: vga_tx
  id: variable_qtgui_range
  parameters:
    comment: |-
      Control de la ventana: ganancia del
      amplificador variable (VGA) del TX de la
      HackRF, de 0 a 47 dB. Se puede cambiar
      mientras transmite.
    gui_hint: 0,1,1,1
    label: Ganancia TX (VGA) [dB]
    min_len: '150'
    start: '0'
    step: '1'
    stop: '47'
    value: '20'
  states: {}
- name: ajuste_amplitud
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      Multiplica la señal por la
      "amplitud" de la ventana,
      para que los picos de I y
      Q no pasen de ±1 (si
      pasan, el DAC de la HackRF
      recorta).
      Entra: complejos.
      Sale: complejos escalados
        (van a la HackRF y a los
        gráficos).
    const: amplitud
    type: complex
  states: {}
- name: archivo
  id: parameter
  parameters:
    comment: |-
      Parámetro: archivo que se transmite (ruta
      desde la carpeta de este .grc, con barras /).
      También se puede elegir al correr el .py:
      --archivo foto.jpg
    label: Archivo a transmitir
    type: str
    value: ../grc_hackrf/Outer.mp3
  states: {}
- name: crc
  id: digital_crc32_bb
  parameters:
    check: 'False'
    comment: |-
      Calcula el CRC-32 de cada paquete y se lo
      agrega al final (4 bytes). El receptor lo
      vuelve a calcular para descartar los paquetes
      con errores.
      Entra: bytes: paquete de N + 2 bytes
        (packet_len).
      Sale: bytes: paquete + CRC = N + 6 bytes
        (packet_len).
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: datos_fuente
  id: blocks_vector_source_x
  parameters:
    comment: |-
      Entrega una y otra vez la lista "datos": el
      archivo + el paquete de descripción.
      Entra: nada (es una fuente).
      Sale: bytes del archivo.
    repeat: 'True'
    type: byte
    vector: datos
  states: {}
- name: datos_paquetes
  id: blocks_stream_to_tagged_stream
  parameters:
    comment: |-
      Corta los datos en grupos de N = 200 bytes
      (uno por paquete) marcados con packet_len =
      200.
      Entra: bytes sin marcas.
      Sale: los mismos bytes, en grupos de N
        marcados con packet_len.
    len_tag_key: '"packet_len"'
    packet_len: N
    type: byte
  states: {}
- name: desplazar
  id: blocks_rotator_cc
  parameters:
    comment: |-
      Corre la señal +400 kHz en frecuencia (la
      multiplica por una exponencial compleja). Así
      queda lejos del pico que deja la HackRF en el
      centro.
      Entra: complejos a 2 M muestras/s, centrados
        en 0 Hz.
      Sale: complejos a 2 M muestras/s, centrados en
        +400 kHz.
    phase_inc: 2 * math.pi * f_offset / samp_rate
  states: {}
- name: encabezado
  id: digital_protocol_formatter_bb
  parameters:
    comment: |-
      Arma el encabezado de cada paquete
      con el formato "formato_trama":
      preámbulo de 64 bits + longitud (2
      veces). Solo produce el
      encabezado, no copia el paquete.
      Entra: bytes: paquete con CRC
        (packet_len).
      Sale: bytes: encabezado de 12
        bytes (packet_len = 12).
    format: formato_trama
    len_tag_key: '"packet_len"'
  states: {}
- name: g_cascada
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    comment: |-
      Gráfico de cascada: el espectro a lo largo del
      tiempo (cada línea es un instante; el color,
      la potencia).
      Entra: complejos a 2 M muestras/s.
      Sale: nada (solo dibuja).
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,1,1,1
    int_max: '0'
    int_min: '-120'
    legend: 'False'
    name: '"Cascada (espectro en el tiempo)"'
    type: complex
  states: {}
- name: g_espectro
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    comment: |-
      Gráfico del espectro que se transmite. El 0
      del eje es la frecuencia elegida - 400 kHz: la
      señal aparece en +400 kHz.
      Entra: complejos a 2 M muestras/s.
      Sale: nada (solo dibuja).
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 2,0,1,1
    label: '"Potencia relativa"'
    label1: TX
    legend: 'False'
    name: '"Espectro que se transmite (centro = frecuencia - 400 kHz)"'
    type: complex
    ymax: '0'
    ymin: '-120'
  states: {}
- name: g_senal
  id: qtgui_time_sink_x
  parameters:
    comment: |-
      Gráfico en el tiempo de I (azul) y Q (rojo),
      lo que le llega a la HackRF: tiene que quedar
      dentro de ±1.
      Entra: complejos a 2 M muestras/s.
      Sale: nada (solo dibuja).
    entags: 'False'
    grid: 'True'
    gui_hint: 2,2,1,2
    label1: I
    label2: Q
    name: '"Señal que entra al HackRF (I y Q, debe quedar dentro de ±1)"'
    size: '400'
    srate: samp_rate
    type: complex
    ylabel: Amplitud
    ymax: '1.1'
    ymin: '-1.1'
  states: {}
- name: imports
  id: import
  parameters:
    comment: |-
      Módulos de Python que usan las variables: os
      (ver si el archivo existe), math, hashlib
      (huella SHA-256) y random (bytes de relleno).
    imports: import os, math, hashlib, random
  states: {}
- name: limite
  id: blocks_head
  parameters:
    comment: |-
      Deja pasar solo "total_bytes" bytes y después
      termina el flujo: así se mandan solo las
      pasadas pedidas. Con repeticiones = 0 no corta
      nunca.
      Entra: bytes.
      Sale: los mismos bytes, hasta llegar al
        límite.
    num_items: total_bytes
    type: byte
  states: {}
- name: modulador
  id: digital_constellation_modulator
  parameters:
    comment: |-
      Modulador 4-QAM: toma los bytes de a 2 bits,
      aplica la codificación diferencial (la
      información va en el cambio de fase entre
      símbolos) y forma cada pulso con un filtro RRC
      (roll-off 0,35).
      Entra: bytes (8 bits cada uno), 62 500
        bytes/s.
      Sale: complejos (I + jQ), 8 muestras por
        símbolo = 2 M muestras/s.
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: nota_paquetes
  id: note
  parameters:
    comment: |-
      ARMADO DE LOS PAQUETES
      paquete = [número (2 bytes) | N bytes del
      archivo]
      -> se le agrega el CRC-32 (4 bytes)
      -> se le pone delante el encabezado: preámbulo
        de 64 bits + longitud (2 veces).
      El último paquete de cada pasada describe el
      archivo: nombre, tamaño y huella SHA-256.
    note: 'PAQUETES: [número (2 bytes) | N bytes del archivo] -> CRC-32 -> preámbulo 64 b + longitud x2. El último paquete de cada pasada lleva nombre, tamaño y huella SHA-256 del archivo.'
  states: {}
- name: nota_pasada
  id: note
  parameters:
    comment: |-
      PASADA = [relleno de W bytes | n_paq tramas]
      El Head corta después de "repeticiones"
      pasadas (y de un relleno final).
    note: PASADA = [relleno W bytes | n_paq tramas]. Head corta después de 'repeticiones' pasadas (y un relleno final).
  states: {}
- name: nota_rf
  id: note
  parameters:
    comment: |-
      MODULACIÓN Y RF
      4-QAM diferencial + filtro RRC (8 muestras por
      símbolo) -> se corre +400 kHz -> amplitud ->
      HackRF (sintonizada en la frecuencia elegida -
      400 kHz).
    note: 4-QAM diferencial + RRC (8 muestras/símbolo) -> se corre +400 kHz -> amplitud -> HackRF (sintonizado en la frecuencia elegida menos 400 kHz)
  states: {}
- name: paquete
  id: blocks_tagged_stream_mux
  parameters:
    comment: |-
      Une cada número con sus datos: toma un grupo
      de la entrada 0 y después uno de la entrada 1.
      Entra: in0 = número (2 bytes), in1 = datos (N
        bytes), los dos con packet_len.
      Sale: bytes: paquete [número | datos] de N + 2
        bytes, con packet_len.
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: pasada
  id: blocks_stream_mux
  parameters:
    comment: |-
      Arma cada pasada: copia W bytes de la entrada
      0 (relleno), después n_paq tramas de la
      entrada 1, y vuelve a empezar. Cuenta bytes:
      no mira las etiquetas.
      Entra: in0 = relleno, in1 = tramas (bytes).
      Sale: bytes: [relleno | tramas] [relleno |
        tramas] ...
    lengths: '[W, n_paq * bytes_trama]'
    type: byte
  states: {}
- name: relleno_fuente
  id: blocks_vector_source_x
  parameters:
    comment: |-
      Entrega una y otra vez los W bytes de relleno
      al azar.
      Entra: nada (es una fuente).
      Sale: bytes de relleno.
    repeat: 'True'
    type: byte
    vector: relleno
  states: {}
- name: repeticiones
  id: parameter
  parameters:
    comment: |-
      Parámetro: cuántas veces se manda el archivo
      completo (pasadas). 0 = sin fin, hasta cerrar
      la ventana. Al correr el .py: --repeticiones 5
    label: Veces que se envía el archivo (0 = sin fin)
    type: intx
    value: '0'
  states: {}
- name: sec_fuente
  id: blocks_vector_source_x
  parameters:
    comment: |-
      Entrega una y otra vez la lista "secuencia":
      los números de paquete 0, 1, 2, ...
      Entra: nada (es una fuente).
      Sale: bytes: 2 por paquete (byte alto y byte
        bajo del número).
    repeat: 'True'
    type: byte
    vector: secuencia
  states: {}
- name: sec_paquetes
  id: blocks_stream_to_tagged_stream
  parameters:
    comment: |-
      Corta el flujo en grupos de 2 bytes
      y marca el comienzo de cada grupo
      con la etiqueta packet_len = 2. Así
      los bloques siguientes saben dónde
      empieza y termina cada paquete.
      Entra: bytes sin marcas (números de
        paquete).
      Sale: los mismos bytes, en grupos de
        2 marcados con packet_len.
    len_tag_key: '"packet_len"'
    packet_len: '2'
    type: byte
  states: {}
- name: trama
  id: blocks_tagged_stream_mux
  parameters:
    comment: |-
      Pone el encabezado delante del paquete: arma
      la trama completa.
      Entra: in0 = encabezado (12 bytes), in1 =
        paquete con CRC (N + 6 bytes).
      Sale: bytes: trama de N + 18 bytes
        (packet_len).
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: nota_simulada
  id: note
  parameters:
    comment: |-
      VERSIÓN SIMULADA, generada por
      generar_grc_simulados.py a partir de
      ../grc_hackrf/hackrf_tx_archivo.grc.
      Es igual al original, salvo los bloques que
      dicen "HackRF SIMULADA": en lugar de la placa
      usa el emulador (python
      hackrf_simulada/emulador_hackrf.py, corriendo
      antes de apretar F6).
      Además transmite sin fin (repeticiones = 0):
      cerrar la ventana cuando se terminó de
      revisar.
      No editar este archivo: cambiar el original y
      volver a generar.
    note: 'VERSIÓN SIMULADA, generada por generar_grc_simulados.py a partir de ../grc_hackrf/hackrf_tx_archivo.grc. Es igual al original, salvo los bloques que dicen "HackRF SIMULADA": en lugar de la placa usa el emulador (python hackrf_simulada/emulador_hackrf.py, corriendo antes de apretar F6). Además transmite sin fin (repeticiones = 0): cerrar la ventana cuando se terminó de revisar. No editar este archivo: cambiar el original y volver a generar.'
  states: {}
- name: ajustes_hackrf
  id: variable
  parameters:
    comment: |-
      HackRF SIMULADA: texto con lo que el bloque
      Soapy le pediría a la placa (frecuencia,
      muestreo y ganancias). Cambia cuando se mueve
      un control de la ventana.
    value: ("equipo=tx frecuencia=%r muestreo=%r vga=%r amp=%d" % (float(freq_mhz * 1e6 - f_offset), float(samp_rate), float(vga_tx), bool(amp_tx))).encode()
  states: {}
- name: ajustes_periodicos
  id: blocks_message_strobe
  parameters:
    comment: |-
      HackRF SIMULADA: repite el texto de los
      ajustes cada 200 ms, como un mensaje (si
      cambia un control, cambia el mensaje).
      Entra: nada (es una fuente de mensajes).
      Sale: mensajes (PDU) con el texto de los
        ajustes.
    msg: pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(ajustes_hackrf), list(ajustes_hackrf)))
    period: '200'
  states: {}
- name: ajustes_red
  id: network_socket_pdu
  parameters:
    comment: |-
      HackRF SIMULADA: manda cada mensaje por UDP al
      emulador (127.0.0.1:5552), que así usa la
      frecuencia y las ganancias elegidas.
      Entra: mensajes (PDU).
      Sale: nada (van por la red, sin salir de la
        PC).
    type: UDP_CLIENT
    host: 127.0.0.1
    port: '5552'
    mtu: '10000'
  states: {}
- name: hackrf_tx
  id: network_tcp_sink
  parameters:
    comment: |-
      HackRF SIMULADA: en lugar de la placa, manda
      las muestras por TCP al emulador
      (127.0.0.1:5550), que las toma a 2 M
      muestras/s (samp_rate), como la placa.
      Entra: complejos, con I y Q entre -1 y 1.
      Sale: nada en el flowgraph: van al emulador.
    type: complex
    mode: '1'
    addr: 127.0.0.1
    port: '5550'
  states: {}

connections:
- [ajuste_amplitud, '0', g_cascada, '0']
- [ajuste_amplitud, '0', g_espectro, '0']
- [ajuste_amplitud, '0', g_senal, '0']
- [ajuste_amplitud, '0', hackrf_tx, '0']
- [crc, '0', encabezado, '0']
- [crc, '0', trama, '1']
- [datos_fuente, '0', datos_paquetes, '0']
- [datos_paquetes, '0', paquete, '1']
- [desplazar, '0', ajuste_amplitud, '0']
- [encabezado, '0', trama, '0']
- [limite, '0', modulador, '0']
- [modulador, '0', desplazar, '0']
- [paquete, '0', crc, '0']
- [pasada, '0', limite, '0']
- [relleno_fuente, '0', pasada, '0']
- [sec_fuente, '0', sec_paquetes, '0']
- [sec_paquetes, '0', paquete, '0']
- [trama, '0', pasada, '1']
- [ajustes_periodicos, strobe, ajustes_red, pdus]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
