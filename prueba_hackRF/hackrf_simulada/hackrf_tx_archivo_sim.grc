options:
  parameters:
    author: Juan Gerez
    description: 'VERSIÓN SIMULADA de grc_hackrf/hackrf_tx_archivo.grc (la genera hackrf_simulada/generar_grc_simulados.py): en lugar de una HackRF usa emulador_hackrf.py. Transmite un archivo en paquetes numerados (CRC-32, preámbulo y longitud) con 4-QAM diferencial por un HackRF; solo bloques estándar de GNU Radio'
    generate_options: qt_gui
    id: hackrf_tx_archivo_sim
    output_language: python
    title: '[SIMULADA] HackRF TX: transmisión de un archivo (4-QAM, bloques estándar)'
  states: {}

blocks:
- name: imports
  id: import
  parameters:
    imports: import os, math, hashlib, random
  states: {}
- name: archivo
  id: parameter
  parameters:
    label: Archivo a transmitir
    type: str
    value: ../grc_hackrf/archivo_a_enviar.txt
  states: {}
- name: repeticiones
  id: parameter
  parameters:
    label: Veces que se envía el archivo (0 = sin fin)
    type: intx
    value: '3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Muestras por segundo del HackRF (2 M es el mínimo recomendado)
    value: 2e6
  states: {}
- name: sps
  id: variable
  parameters:
    comment: 'Muestras por símbolo en el TX: 2 M / 8 = 250 000 símbolos/s = 500 kbit/s'
    value: '8'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    comment: Factor de roll-off del filtro RRC (igual que en la simulación)
    value: '0.35'
  states: {}
- name: f_offset
  id: variable
  parameters:
    comment: 'Desplazamiento digital [Hz]: el HackRF se sintoniza 400 kHz más abajo y la señal se corre +400 kHz, así la portadora residual del oscilador (pico en el centro del espectro) queda fuera de la señal'
    value: 400e3
  states: {}
- name: N
  id: variable
  parameters:
    comment: Bytes del archivo por paquete (tiene que ser el mismo número en el receptor)
    value: '200'
  states: {}
- name: W
  id: variable
  parameters:
    comment: 'Bytes de relleno al comienzo de cada pasada: dan tiempo a que el receptor se enganche'
    value: '2500'
  states: {}
- name: dispositivo
  id: variable
  parameters:
    comment: 'Para elegir un HackRF: "serial=..." (ver hackrf_info). Vacío = el primero'
    value: '""'
  states: {}
- name: encontrado
  id: variable
  parameters:
    value: os.path.isfile(archivo)
  states: {}
- name: contenido
  id: variable
  parameters:
    comment: Bytes del archivo (si no se encuentra, se envía un aviso de texto)
    value: list(open(archivo, "rb").read()) if encontrado else list(("No se encontro el archivo " + archivo).encode())
  states: {}
- name: nombre
  id: variable
  parameters:
    value: os.path.basename(archivo) if encontrado else "ERROR_archivo_no_encontrado.txt"
  states: {}
- name: huella
  id: variable
  parameters:
    comment: 'Huella SHA-256 del archivo: el receptor la usa para comprobar que llegó idéntico'
    value: hashlib.sha256(bytes(contenido)).hexdigest()
  states: {}
- name: n_datos
  id: variable
  parameters:
    comment: Paquetes con datos del archivo
    value: (len(contenido) + N - 1) // N
  states: {}
- name: n_paq
  id: variable
  parameters:
    comment: 'Paquetes por pasada: los de datos + uno final con nombre, tamaño y huella'
    value: n_datos + 1
  states: {}
- name: descripcion
  id: variable
  parameters:
    comment: 'Último paquete de cada pasada: ARCHIVO|nombre (hasta 40 bytes)|tamaño|N|paquetes|huella|'
    value: list(b"ARCHIVO|" + nombre.encode()[:40] + ("|%d|%d|%d|%s|" % (len(contenido), N, n_paq, huella)).encode())
  states: {}
- name: datos
  id: variable
  parameters:
    comment: 'Datos de una pasada: archivo completado con ceros hasta N bytes por paquete + paquete final'
    value: contenido + [0] * (n_datos * N - len(contenido)) + (descripcion + [0] * N)[:N]
  states: {}
- name: secuencia
  id: variable
  parameters:
    comment: 'Número de cada paquete (2 bytes): 0, 1, 2, ... n_paq-1'
    value: '[b for i in range(n_paq) for b in ((i // 256) % 256, i % 256)]'
  states: {}
- name: relleno
  id: variable
  parameters:
    comment: 'Bytes al azar (sin preámbulo): no son tramas'
    value: list(random.Random(1).randbytes(W))
  states: {}
- name: bytes_trama
  id: variable
  parameters:
    comment: preámbulo 8 + longitud 4 + número 2 + datos N + CRC 4
    value: N + 18
  states: {}
- name: bytes_pasada
  id: variable
  parameters:
    value: W + n_paq * bytes_trama
  states: {}
- name: total_bytes
  id: variable
  parameters:
    comment: Bytes que se envían en total (+ un relleno final para que salga la última trama)
    value: repeticiones * bytes_pasada + W if repeticiones > 0 else 2**62
  states: {}
- name: duracion_pasada
  id: variable
  parameters:
    comment: Segundos que dura una pasada (2 bits por símbolo)
    value: bytes_pasada * 8 / 2 / (samp_rate / sps)
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[-0.707-0.707j, 0.707-0.707j, +0.707+0.707j, -0.707+0.707j]'
    sym_map: '[0, 1, 3, 2]'
    rot_sym: '4'
    real_sect: '2'
    imag_sect: '2'
    w_real_sect: '1'
    w_imag_sect: '1'
  states: {}
- name: formato_trama
  id: variable_header_format_default
  parameters:
    access_code: '0'
    threshold: '0'
    bps: '1'
  states: {}
- name: freq_mhz
  id: variable_qtgui_entry
  parameters:
    label: Frecuencia [MHz]
    type: real
    value: '915'
    gui_hint: 0,0,1,1
  states: {}
- name: vga_tx
  id: variable_qtgui_range
  parameters:
    label: Ganancia TX (VGA) [dB]
    value: '20'
    start: '0'
    stop: '47'
    step: '1'
    min_len: '150'
    gui_hint: 0,1,1,1
  states: {}
- name: amp_tx
  id: variable_qtgui_check_box
  parameters:
    label: Amplificador TX (+14 dB)
    type: bool
    value: 'False'
    'true': 'True'
    'false': 'False'
    gui_hint: 0,2,1,1
  states: {}
- name: amplitud
  id: variable_qtgui_range
  parameters:
    label: Amplitud digital (pico < 1)
    value: '0.5'
    start: '0.05'
    stop: '0.7'
    step: '0.05'
    min_len: '150'
    gui_hint: 0,3,1,1
  states: {}
- name: enviados
  id: variable_function_probe
  parameters:
    block_id: limite
    function_name: nitems_written
    function_args: '0'
    poll_rate: '2'
    value: '0'
  states: {}
- name: lbl_archivo
  id: variable_qtgui_label
  parameters:
    label: 'Archivo: '
    type: string
    value: '"%s (%d bytes)" % (nombre, len(contenido))'
    gui_hint: 1,0,1,1
  states: {}
- name: lbl_paquetes
  id: variable_qtgui_label
  parameters:
    label: 'Paquetes por pasada: '
    type: string
    value: '"%d (%.2f s cada pasada)" % (n_paq, duracion_pasada)'
    gui_hint: 1,1,1,1
  states: {}
- name: lbl_huella
  id: variable_qtgui_label
  parameters:
    label: 'SHA-256: '
    type: string
    value: huella[:16] + "..."
    gui_hint: 1,2,1,1
  states: {}
- name: lbl_pasadas
  id: variable_qtgui_label
  parameters:
    label: 'Pasadas enviadas: '
    type: real
    value: min(enviados, total_bytes - W) / bytes_pasada
    formatter: 'lambda x: ''%.2f'' % x'
    gui_hint: 1,3,1,1
  states: {}
- name: nota_paquetes
  id: note
  parameters:
    note: 'PAQUETES: [número (2 bytes) | N bytes del archivo] -> CRC-32 -> preámbulo 64 b + longitud x2. El último paquete de cada pasada lleva nombre, tamaño y huella SHA-256 del archivo.'
  states: {}
- name: sec_fuente
  id: blocks_vector_source_x
  parameters:
    type: byte
    vector: secuencia
    repeat: 'True'
  states: {}
- name: sec_paquetes
  id: blocks_stream_to_tagged_stream
  parameters:
    type: byte
    packet_len: '2'
    len_tag_key: '"packet_len"'
  states: {}
- name: datos_fuente
  id: blocks_vector_source_x
  parameters:
    type: byte
    vector: datos
    repeat: 'True'
  states: {}
- name: datos_paquetes
  id: blocks_stream_to_tagged_stream
  parameters:
    type: byte
    packet_len: N
    len_tag_key: '"packet_len"'
  states: {}
- name: paquete
  id: blocks_tagged_stream_mux
  parameters:
    type: byte
    ninputs: '2'
    lengthtagname: '"packet_len"'
  states: {}
- name: crc
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: encabezado
  id: digital_protocol_formatter_bb
  parameters:
    format: formato_trama
    len_tag_key: '"packet_len"'
  states: {}
- name: trama
  id: blocks_tagged_stream_mux
  parameters:
    type: byte
    ninputs: '2'
    lengthtagname: '"packet_len"'
  states: {}
- name: nota_pasada
  id: note
  parameters:
    note: PASADA = [relleno W bytes | n_paq tramas]. Head corta después de 'repeticiones' pasadas (y un relleno final).
  states: {}
- name: relleno_fuente
  id: blocks_vector_source_x
  parameters:
    type: byte
    vector: relleno
    repeat: 'True'
  states: {}
- name: pasada
  id: blocks_stream_mux
  parameters:
    type: byte
    lengths: '[W, n_paq * bytes_trama]'
  states: {}
- name: limite
  id: blocks_head
  parameters:
    type: byte
    num_items: total_bytes
  states: {}
- name: nota_rf
  id: note
  parameters:
    note: 4-QAM diferencial + RRC (8 muestras/símbolo) -> se corre +400 kHz -> amplitud -> HackRF (sintonizado en la frecuencia elegida menos 400 kHz)
  states: {}
- name: modulador
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    samples_per_symbol: sps
    excess_bw: excess_bw
  states: {}
- name: desplazar
  id: blocks_rotator_cc
  parameters:
    phase_inc: 2 * math.pi * f_offset / samp_rate
  states: {}
- name: ajuste_amplitud
  id: blocks_multiply_const_vxx
  parameters:
    type: complex
    const: amplitud
  states: {}
- name: g_espectro
  id: qtgui_freq_sink_x
  parameters:
    type: complex
    name: '"Espectro que se transmite (centro = frecuencia - 400 kHz)"'
    gui_hint: 2,0,1,1
    fftsize: '1024'
    fc: '0'
    bw: samp_rate
    average: '0.2'
    grid: 'True'
    legend: 'False'
    label: '"Potencia relativa"'
    ymin: '-120'
    ymax: '0'
    label1: TX
  states: {}
- name: g_cascada
  id: qtgui_waterfall_sink_x
  parameters:
    type: complex
    name: '"Cascada (espectro en el tiempo)"'
    fftsize: '1024'
    fc: '0'
    bw: samp_rate
    int_min: '-120'
    int_max: '0'
    gui_hint: 2,1,1,1
    legend: 'False'
  states: {}
- name: g_senal
  id: qtgui_time_sink_x
  parameters:
    type: complex
    name: '"Señal que entra al HackRF (I y Q, debe quedar dentro de ±1)"'
    gui_hint: 2,2,1,2
    size: '400'
    srate: samp_rate
    ymin: '-1.1'
    ymax: '1.1'
    ylabel: Amplitud
    grid: 'True'
    entags: 'False'
    label1: I
    label2: Q
  states: {}
- name: nota_simulada
  id: note
  parameters:
    note: |-
      VERSIÓN SIMULADA, generada por generar_grc_simulados.py a partir de ../grc_hackrf/hackrf_tx_archivo.grc.
      Es igual al original, salvo los bloques de esta franja: en lugar de la HackRF usa el emulador
      (python hackrf_simulada/emulador_hackrf.py, corriendo antes de apretar F6).
      No editar este archivo: cambiar el original y volver a generar.
  states: {}
- name: hackrf_tx
  id: network_tcp_sink
  parameters:
    comment: 'HackRF SIMULADA: manda las muestras al emulador, que las toma a samp_rate muestras/s como la placa'
    type: complex
    mode: '1'
    addr: 127.0.0.1
    port: '5550'
  states: {}
- name: ajustes_hackrf
  id: variable
  parameters:
    comment: Lo que el bloque Soapy le pediría a la placa (frecuencia, muestreo, ganancias), como texto
    value: ("equipo=tx frecuencia=%r muestreo=%r vga=%r amp=%d" % (float(freq_mhz * 1e6 - f_offset), float(samp_rate), float(vga_tx), bool(amp_tx))).encode()
  states: {}
- name: ajustes_periodicos
  id: blocks_message_strobe
  parameters:
    comment: Repite los ajustes cada 200 ms (si cambian en la interfaz, cambia el mensaje)
    msg: pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(ajustes_hackrf), list(ajustes_hackrf)))
    period: '200'
  states: {}
- name: ajustes_red
  id: network_socket_pdu
  parameters:
    comment: Manda los ajustes al emulador (UDP)
    type: UDP_CLIENT
    host: 127.0.0.1
    port: '5552'
    mtu: '10000'
  states: {}

connections:
- [sec_fuente, '0', sec_paquetes, '0']
- [datos_fuente, '0', datos_paquetes, '0']
- [sec_paquetes, '0', paquete, '0']
- [datos_paquetes, '0', paquete, '1']
- [paquete, '0', crc, '0']
- [crc, '0', encabezado, '0']
- [encabezado, '0', trama, '0']
- [crc, '0', trama, '1']
- [relleno_fuente, '0', pasada, '0']
- [trama, '0', pasada, '1']
- [pasada, '0', limite, '0']
- [limite, '0', modulador, '0']
- [modulador, '0', desplazar, '0']
- [desplazar, '0', ajuste_amplitud, '0']
- [ajuste_amplitud, '0', hackrf_tx, '0']
- [ajuste_amplitud, '0', g_espectro, '0']
- [ajuste_amplitud, '0', g_cascada, '0']
- [ajuste_amplitud, '0', g_senal, '0']
- [ajustes_periodicos, strobe, ajustes_red, pdus]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
