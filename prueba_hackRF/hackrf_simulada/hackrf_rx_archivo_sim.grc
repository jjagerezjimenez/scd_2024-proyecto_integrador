options:
  parameters:
    author: Juan Gerez
    description: 'VERSIÓN SIMULADA de grc_hackrf/hackrf_rx_archivo.grc (la genera hackrf_simulada/generar_grc_simulados.py): en lugar de una HackRF usa emulador_hackrf.py. Recibe con un HackRF los paquetes de hackrf_tx_archivo.grc (FLL, sincronismo, Costas, CRC-32) y guarda los correctos en paquetes_recibidos.bin y datos_recibidos.bin; solo bloques estándar de GNU Radio'
    generate_options: qt_gui
    id: hackrf_rx_archivo_sim
    output_language: python
    title: '[SIMULADA] HackRF RX: recepción de un archivo (4-QAM, bloques estándar)'
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    comment: Bytes del archivo por paquete (igual que en el transmisor)
    value: '200'
  states: {}
- name: amp_rx
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 0,1,1,1
    label: Amplificador RX (+11 dB)
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: ber_est
  id: variable
  parameters:
    comment: BER teórico de 4-QAM diferencial para el Eb/N0 estimado
    value: 2 * p_est * (1 - p_est)
  states: {}
- name: cfo_hz
  id: variable
  parameters:
    comment: Desvío de frecuencia de la señal recibida [Hz] (FLL + Costas; corrigen con el signo opuesto)
    value: '-(w_fll * samp_rate_rx + w_costas * samp_rate_rx / sps) / (2 * math.pi)'
  states: {}
- name: costas_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: BW lazo de Costas
    min_len: '100'
    start: '0.001'
    step: '0.001'
    stop: '0.1'
    value: '0.01'
    widget: counter
  states: {}
- name: decim
  id: variable
  parameters:
    comment: 'Diezmado: después de filtrar quedan 1 M muestras/s'
    value: '2'
  states: {}
- name: dispositivo
  id: variable
  parameters:
    comment: 'Para elegir un HackRF: "serial=..." (ver hackrf_info). Vacío = el primero'
    value: '""'
  states: {}
- name: eb_n0_db
  id: variable
  parameters:
    comment: Eb/N0 = Es/N0 - 3 dB (2 bits por símbolo)
    value: es_n0_db - 10 * math.log10(2)
  states: {}
- name: es_n0_db
  id: variable_function_probe
  parameters:
    block_id: estimador_snr
    function_name: snr
    poll_rate: '2'
    value: '0'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    comment: Factor de roll-off del filtro RRC
    value: '0.35'
  states: {}
- name: f_offset
  id: variable
  parameters:
    comment: Desplazamiento digital [Hz] (igual que en el transmisor)
    value: 400e3
  states: {}
- name: fll_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: BW lazo FLL
    min_len: '100'
    start: '0.001'
    step: '0.001'
    stop: '0.1'
    value: '0.005'
    widget: counter
  states: {}
- name: freq_mhz
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,1
    label: Frecuencia [MHz]
    type: real
    value: '915'
  states: {}
- name: items_detectados
  id: variable_function_probe
  parameters:
    block_id: detector_trama
    function_args: '0'
    function_name: nitems_written
    poll_rate: '2'
    value: '0'
  states: {}
- name: items_ok
  id: variable_function_probe
  parameters:
    block_id: crc
    function_args: '0'
    function_name: nitems_written
    poll_rate: '2'
    value: '0'
  states: {}
- name: lbl_ber
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: ''%.1e'' % x if x == x else ''-'''
    gui_hint: 2,3,1,1
    label: 'BER teórico (Eb/N0 est.): '
    type: real
    value: ber_est
  states: {}
- name: lbl_cfo
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: ''%.0f Hz'' % x'
    gui_hint: 1,3,1,1
    label: 'Desvío de frecuencia: '
    type: real
    value: cfo_hz
  states: {}
- name: lbl_detectadas
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,4,1,1
    label: 'Tramas detectadas: '
    type: int
    value: tramas_detectadas
  states: {}
- name: lbl_ebn0
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: ''%.1f dB'' % x if x == x else ''sin señal'''
    gui_hint: 2,2,1,1
    label: 'Eb/N0 estimado: '
    type: real
    value: eb_n0_db
  states: {}
- name: lbl_mal
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,1,1,1
    label: 'Descartadas por CRC: '
    type: int
    value: max(tramas_detectadas - paquetes_ok, 0)
  states: {}
- name: lbl_ok
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,0,1,1
    label: 'Con CRC correcto: '
    type: int
    value: paquetes_ok
  states: {}
- name: lbl_per
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: ''%.1e'' % x if x == x else ''-'''
    gui_hint: 2,4,1,1
    label: 'PER teórico (Eb/N0 est.): '
    type: real
    value: per_est
  states: {}
- name: lbl_ppm
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: ''%.1f'' % x'
    gui_hint: 1,4,1,1
    label: 'Desvío [ppm]: '
    type: real
    value: cfo_hz / freq_mhz
  states: {}
- name: lna
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: Ganancia LNA [dB]
    min_len: '120'
    start: '0'
    step: '8'
    stop: '40'
    value: '16'
  states: {}
- name: p_est
  id: variable
  parameters:
    value: 0.5 * math.erfc(math.sqrt(10 ** (eb_n0_db / 10)))
  states: {}
- name: paquetes_ok
  id: variable
  parameters:
    comment: Paquetes con CRC correcto (2 + N bytes cada uno)
    value: int(items_ok) // (N + 2)
  states: {}
- name: per_est
  id: variable
  parameters:
    comment: 'PER teórico: cada error del canal arruina 2 bits seguidos de la MISMA trama -> depende de p, no del BER'
    value: 1 - (1 - p_est) ** (8 * (N + 18))
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[-0.707-0.707j, 0.707-0.707j, +0.707+0.707j, -0.707+0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Muestras por segundo del HackRF (igual que en el transmisor)
    value: 2e6
  states: {}
- name: samp_rate_rx
  id: variable
  parameters:
    value: samp_rate / decim
  states: {}
- name: sps
  id: variable
  parameters:
    comment: Muestras por símbolo en el receptor (250 000 símbolos/s, como en el transmisor)
    value: '4'
  states: {}
- name: sync_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,2,1,1
    label: BW sinc. de símbolo
    min_len: '100'
    start: '0.001'
    step: '0.001'
    stop: '0.1'
    value: '0.01'
    widget: counter
  states: {}
- name: taps_canal
  id: variable
  parameters:
    comment: 'Filtro pasabajos del canal: deja pasar la señal (±170 kHz, +40 kHz de desvío) y elimina la portadora residual y lo demás'
    value: firdes.low_pass(1, samp_rate, 300e3, 100e3)
  states: {}
- name: tramas_detectadas
  id: variable
  parameters:
    comment: Tramas cuyo preámbulo se encontró (el detector entrega N + 6 bytes en bits)
    value: int(items_detectados) // (8 * (N + 6))
  states: {}
- name: umbral
  id: variable
  parameters:
    comment: Bits erróneos tolerados al buscar el preámbulo de 64 bits
    value: '12'
  states: {}
- name: vga_rx
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,1
    label: Ganancia VGA [dB]
    min_len: '120'
    start: '0'
    step: '2'
    stop: '62'
    value: '20'
  states: {}
- name: w_costas
  id: variable_function_probe
  parameters:
    block_id: costas_sonda
    function_name: level
    poll_rate: '2'
    value: '0'
  states: {}
- name: w_fll
  id: variable_function_probe
  parameters:
    block_id: fll_sonda
    function_name: level
    poll_rate: '2'
    value: '0'
  states: {}
- name: a_bits
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: a_bytes
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
    minoutbuf: '70000'
  states: {}
- name: acelerador
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: agc
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-2'
    decay_rate: '1e-3'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: alto_f
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: archivo_datos
  id: blocks_file_sink
  parameters:
    file: '"datos_recibidos.bin"'
    type: byte
    unbuffered: 'True'
  states: {}
- name: archivo_paquetes
  id: blocks_file_sink
  parameters:
    file: '"paquetes_recibidos.bin"'
    type: byte
    unbuffered: 'True'
  states: {}
- name: bajo_f
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: costas
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: costas_bw
  states: {}
- name: costas_promedio
  id: blocks_moving_average_xx
  parameters:
    length: '25000'
    max_iter: '4000'
    scale: 1.0 / 25000
    type: float
  states: {}
- name: costas_sonda
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: crc
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    minoutbuf: '70000'
    packed: 'True'
  states: {}
- name: dec_diferencial
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: decisor
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: detector_trama
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: digital.packet_utils.default_access_code
    minoutbuf: '600000'
    tagname: '"packet_len"'
    threshold: umbral
    type: byte
  states: {}
- name: entrada
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {}
- name: estimador_snr
  id: digital_probe_mpsk_snr_est_c
  parameters:
    alpha: '0.001'
    msg_nsamples: '10000'
    type: '2'
  states: {}
- name: filtro_adaptado
  id: filter_fft_rrc_filter
  parameters:
    alpha: excess_bw
    decim: '1'
    gain: '1'
    ntaps: 11 * sps
    samp_rate: samp_rate_rx
    sym_rate: samp_rate_rx / sps
    type: ccc
  states: {}
- name: fll
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '44'
    rolloff: excess_bw
    samps_per_sym: sps
    type: cc
    w: fll_bw
  states: {}
- name: fll_hz
  id: blocks_multiply_const_vxx
  parameters:
    const: '-samp_rate_rx / (2 * math.pi)'
    type: float
  states: {}
- name: fll_null_2
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: fll_null_3
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: fll_promedio
  id: blocks_moving_average_xx
  parameters:
    length: '100000'
    max_iter: '4000'
    scale: 1.0 / 100000
    type: float
  states: {}
- name: fll_sonda
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: g_agc
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: 'pestanas@0: 1,1,1,2'
    label1: I
    label2: Q
    name: '"Después del AGC (nivel normalizado)"'
    size: '400'
    srate: samp_rate_rx
    type: complex
    ylabel: Amplitud
    ymax: '2'
    ymin: '-2'
  states: {}
- name: g_cascada
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 'pestanas@0: 0,1,1,1'
    int_max: '0'
    int_min: '-120'
    legend: 'False'
    name: '"Cascada (espectro en el tiempo)"'
    type: complex
  states: {}
- name: g_const
  id: qtgui_const_sink_x
  parameters:
    alpha1: '0.6'
    alpha2: '0.6'
    grid: 'True'
    gui_hint: 'pestanas@1: 0,2,1,1'
    label1: Antes
    label2: Después
    name: '"Constelación antes y después de Costas"'
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: g_crudo
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: 'pestanas@0: 0,2,1,1'
    label1: I
    label2: Q
    name: '"Señal cruda del HackRF (si toca ±1, bajar ganancias)"'
    size: '1000'
    srate: samp_rate
    type: complex
    ylabel: Amplitud
    ymax: '1.1'
    ymin: '-1.1'
  states: {}
- name: g_espectro_banda
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate_rx
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 'pestanas@0: 1,0,1,1'
    label: '"Potencia relativa"'
    label1: Banda base
    legend: 'False'
    name: '"Espectro trasladado y filtrado (1 M muestras/s)"'
    type: complex
    ymax: '0'
    ymin: '-120'
  states: {}
- name: g_espectro_crudo
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 'pestanas@0: 0,0,1,1'
    label: '"Potencia relativa"'
    label1: RX
    legend: 'False'
    name: '"Espectro del HackRF (señal en +400 kHz; pico del oscilador en 0)"'
    type: complex
    ymax: '0'
    ymin: '-120'
  states: {}
- name: g_fll
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: 'pestanas@1: 0,0,1,1'
    label1: FLL
    legend: 'False'
    name: '"Desvío de frecuencia que estima el FLL [Hz]"'
    size: '2000'
    srate: samp_rate_rx
    type: float
    ylabel: Hz
    ymax: '60000.0'
    ymin: '-60000.0'
  states: {}
- name: g_numero
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    grid: 'True'
    gui_hint: 'pestanas@2: 0,0,1,3'
    label1: Paquete
    legend: 'False'
    marker1: '0'
    name: '"Número de cada paquete recibido con CRC correcto (los saltos son paquetes perdidos)"'
    size: '1000'
    srate: samp_rate_rx / sps / (8 * (N + 18) / 2)
    style1: '0'
    type: float
    ylabel: Número de paquete
    ymax: '300'
    ymin: '-5'
  states: {}
- name: g_ojo
  id: qtgui_eye_sink_x
  parameters:
    alpha1: '0.5'
    entags: 'False'
    grid: 'True'
    gui_hint: 'pestanas@1: 0,1,1,1'
    label1: Ojo de I (antes de Costas)
    samp_per_symbol: 4*sps
    size: '1024'
    srate: 4 * samp_rate_rx
    type: float
    ylabel: '"Amplitud"'
    ymax: '2'
    ymin: '-2'
  states: {}
- name: grabar_iq
  id: blocks_file_sink
  parameters:
    file: '"grabacion_iq.cf32"'
    type: complex
  states: {state: disabled}
- name: imports
  id: import
  parameters:
    imports: |-
      import math
      from gnuradio.filter import firdes
  states: {}
- name: leer_grabacion
  id: blocks_file_source
  parameters:
    file: '"grabacion_iq.cf32"'
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: mapa_gray
  id: digital_map_bb
  parameters:
    map: '[0, 1, 3, 2]'
  states: {}
- name: nota_entrada
  id: note
  parameters:
    note: 'ENTRADA: HackRF sintonizado 400 kHz por debajo (la señal aparece en +400 kHz). Para grabar la señal, habilitar ''grabar_iq''; para analizar una grabación sin HackRF, deshabilitar ''hackrf_rx'' y habilitar ''leer_grabacion'' y ''acelerador''.'
  states: {}
- name: nota_paquetes
  id: note
  parameters:
    note: 'PAQUETES: detector de tramas (preámbulo + longitud) -> bytes -> CRC-32 (descarta las erróneas). paquetes_recibidos.bin = [número | datos] de cada paquete correcto (lo usa reconstruir_archivo.py); datos_recibidos.bin = solo los datos, en el orden en que llegaron.'
  states: {}
- name: nota_rx
  id: note
  parameters:
    note: 'RECEPTOR: trasladar -400 kHz y filtrar (1 M muestras/s) -> AGC (nivel 1) -> FLL band-edge (corrige el desvío grueso entre osciladores, kHz) -> filtro adaptado RRC -> sincronismo de símbolo -> Costas -> decisión -> decodificación diferencial -> bits'
  states: {}
- name: numero_paquete
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: ojo_interp
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '4'
    type: ccc
  states: {}
- name: ojo_re
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: pestanas
  id: qtgui_tab_widget
  parameters:
    gui_hint: 3,0,1,5
    label0: 1. Señal del HackRF
    label1: 2. Sincronismo (frecuencia, tiempo y fase)
    label2: 3. Paquetes recibidos
    num_tabs: '3'
  states: {}
- name: por_256
  id: blocks_multiply_const_vxx
  parameters:
    const: '256'
    type: float
  states: {}
- name: separar_bytes
  id: blocks_deinterleave
  parameters:
    type: byte
  states: {}
- name: sinc_null_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: sinc_null_2
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: sinc_null_3
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: sinc_simbolo
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: sync_bw
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: solo_datos
  id: blocks_keep_m_in_n
  parameters:
    m: N
    n: N + 2
    offset: '2'
    type: byte
  states: {}
- name: solo_numero
  id: blocks_keep_m_in_n
  parameters:
    m: '2'
    n: N + 2
    offset: '0'
    type: byte
  states: {}
- name: trasladar
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: f_offset
    decim: decim
    samp_rate: samp_rate
    taps: taps_canal
    type: ccf
  states: {}
- name: nota_simulada
  id: note
  parameters:
    note: |-
      VERSIÓN SIMULADA, generada por generar_grc_simulados.py a partir de ../grc_hackrf/hackrf_rx_archivo.grc.
      Es igual al original, salvo los bloques de esta franja: en lugar de la HackRF usa el emulador
      (python hackrf_simulada/emulador_hackrf.py, corriendo antes de apretar F6).
      No editar este archivo: cambiar el original y volver a generar.
  states: {}
- name: hackrf_rx_red
  id: network_socket_pdu
  parameters:
    comment: Recibe del emulador paquetes UDP con I/Q de 8 bits
    type: UDP_SERVER
    host: 127.0.0.1
    port: '5551'
    mtu: '10000'
  states: {}
- name: hackrf_rx_bytes
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Paquetes de red -> flujo de bytes
    type: byte
    tag: trozo_udp
  states: {}
- name: hackrf_rx_iq
  id: blocks_interleaved_char_to_complex
  parameters:
    comment: Bytes (I, Q) de 8 bits -> complejo entre -1 y 1, como hace el driver de la HackRF
    vector_input: 'False'
    scale_factor: '128'
  states: {}
- name: hackrf_rx
  id: blocks_tag_gate
  parameters:
    comment: Borra las marcas de cada paquete de red
    type: complex
    propagate_tags: 'False'
  states: {}
- name: ajustes_hackrf
  id: variable
  parameters:
    comment: Lo que el bloque Soapy le pediría a la placa (frecuencia, muestreo, ganancias), como texto
    value: ("equipo=rx frecuencia=%r muestreo=%r lna=%r vga=%r amp=%d" % (float(freq_mhz * 1e6 - f_offset), float(samp_rate), float(lna), float(vga_rx), bool(amp_rx))).encode()
  states: {}
- name: ajustes_periodicos
  id: blocks_message_strobe
  parameters:
    comment: Repite los ajustes cada 200 ms (si cambian en la interfaz, cambia el mensaje)
    msg: pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(ajustes_hackrf), list(ajustes_hackrf)))
    period: '200'
  states: {}
- name: ajustes_red
  id: network_socket_pdu
  parameters:
    comment: Manda los ajustes al emulador (UDP)
    type: UDP_CLIENT
    host: 127.0.0.1
    port: '5552'
    mtu: '10000'
  states: {}

connections:
- [a_bits, '0', detector_trama, '0']
- [a_bytes, '0', crc, '0']
- [acelerador, '0', entrada, '0']
- [agc, '0', fll, '0']
- [agc, '0', g_agc, '0']
- [alto_f, '0', por_256, '0']
- [bajo_f, '0', numero_paquete, '1']
- [costas, '0', decisor, '0']
- [costas, '0', estimador_snr, '0']
- [costas, '0', g_const, '1']
- [costas, '1', costas_promedio, '0']
- [costas_promedio, '0', costas_sonda, '0']
- [crc, '0', archivo_paquetes, '0']
- [crc, '0', solo_datos, '0']
- [crc, '0', solo_numero, '0']
- [dec_diferencial, '0', mapa_gray, '0']
- [decisor, '0', dec_diferencial, '0']
- [detector_trama, '0', a_bytes, '0']
- [entrada, '0', g_cascada, '0']
- [entrada, '0', g_crudo, '0']
- [entrada, '0', g_espectro_crudo, '0']
- [entrada, '0', trasladar, '0']
- [filtro_adaptado, '0', ojo_interp, '0']
- [filtro_adaptado, '0', sinc_simbolo, '0']
- [fll, '0', filtro_adaptado, '0']
- [fll, '1', fll_hz, '0']
- [fll, '1', fll_promedio, '0']
- [fll, '2', fll_null_2, '0']
- [fll, '3', fll_null_3, '0']
- [fll_hz, '0', g_fll, '0']
- [fll_promedio, '0', fll_sonda, '0']
- [hackrf_rx, '0', entrada, '0']
- [hackrf_rx, '0', grabar_iq, '0']
- [leer_grabacion, '0', acelerador, '0']
- [mapa_gray, '0', a_bits, '0']
- [numero_paquete, '0', g_numero, '0']
- [ojo_interp, '0', ojo_re, '0']
- [ojo_re, '0', g_ojo, '0']
- [por_256, '0', numero_paquete, '0']
- [separar_bytes, '0', alto_f, '0']
- [separar_bytes, '1', bajo_f, '0']
- [sinc_simbolo, '0', costas, '0']
- [sinc_simbolo, '0', g_const, '0']
- [sinc_simbolo, '1', sinc_null_1, '0']
- [sinc_simbolo, '2', sinc_null_2, '0']
- [sinc_simbolo, '3', sinc_null_3, '0']
- [solo_datos, '0', archivo_datos, '0']
- [solo_numero, '0', separar_bytes, '0']
- [trasladar, '0', agc, '0']
- [trasladar, '0', g_espectro_banda, '0']
- [hackrf_rx_red, pdus, hackrf_rx_bytes, pdus]
- [hackrf_rx_bytes, '0', hackrf_rx_iq, '0']
- [hackrf_rx_iq, '0', hackrf_rx, '0']
- [ajustes_periodicos, strobe, ajustes_red, pdus]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
