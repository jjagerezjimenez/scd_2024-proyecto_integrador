options:
  parameters:
    author: Juan Gerez
    comment: |-
      Opciones del flowgraph: título de la ventana,
      interfaz QT GUI y nombre del programa que arma
      GRC al apretar F6 (halfduplex_4qam.py, en esta
      misma carpeta).
    description: Dos nodos que se turnan un canal compartido (TDD) con tramas (preámbulo + longitud + CRC-32), 4-QAM diferencial y medición de BER; solo bloques estándar de GNU Radio
    generate_options: qt_gui
    id: halfduplex_4qam
    output_language: python
    title: Enlace half-duplex 4-QAM (TDD) con tramas y BER (bloques estándar)
  states: {}

blocks:
- name: L_A
  id: variable
  parameters:
    comment: |-
      Bytes de payload de cada trama del nodo A
      (largo de su mensaje).
    value: len(payload_A)
  states: {}
- name: L_B
  id: variable
  parameters:
    comment: Bytes de payload de cada trama del nodo B.
    value: len(payload_B)
  states: {}
- name: ber_A_log
  id: variable_function_probe
  parameters:
    block_id: rxA_sonda_ber
    comment: |-
      Lee 4 veces por segundo el log10 del BER
      acumulado del nodo A (bloque "rxA_sonda_ber").
    function_name: level
    poll_rate: '4'
    value: '0'
  states: {}
- name: ber_B_log
  id: variable_function_probe
  parameters:
    block_id: rxB_sonda_ber
    comment: |-
      Lee 4 veces por segundo el log10 del BER
      acumulado del nodo B (bloque "rxB_sonda_ber").
    function_name: level
    poll_rate: '4'
    value: '0'
  states: {}
- name: ber_teo
  id: variable
  parameters:
    comment: |-
      BER teórico de 4-QAM con codificación
      diferencial: 2 p (1 - p). Un bit sale mal si
      exactamente uno de los dos símbolos que se
      comparan se decidió mal.
    value: 2 * p_qpsk * (1 - p_qpsk)
  states: {}
- name: cfo_hz
  id: variable_qtgui_range
  parameters:
    comment: |-
      Control de la ventana: diferencia de
      frecuencia entre los osciladores de A y B, en
      Hz (el receptor de B la ve como +CFO y el de A
      como -CFO).
    gui_hint: 0,4,1,2
    label: Desvío entre osciladores A-B [Hz]
    min_len: '150'
    start: '-1000'
    step: '10'
    stop: '1000'
    value: '0'
  states: {}
- name: costas_bw
  id: variable_qtgui_range
  parameters:
    comment: |-
      Control de la ventana: ancho de banda de los
      lazos de Costas. Más grande = corrige más
      rápido, pero con más ruido.
    gui_hint: 1,0,1,1
    label: BW lazo de Costas
    min_len: '100'
    start: '0.001'
    step: '0.001'
    stop: '0.1'
    value: '0.005'
    widget: counter
  states: {}
- name: ebn0_db
  id: variable_qtgui_range
  parameters:
    comment: |-
      Control de la ventana: Eb/N0 del canal en dB
      (0 a 15). Cambia el nivel del ruido (variable
      "ruido").
    gui_hint: 0,0,1,2
    label: Eb/N0 [dB]
    min_len: '150'
    start: '0'
    step: '0.5'
    stop: '15'
    value: '10'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    comment: |-
      Roll-off del filtro RRC (0,35): cuánto más
      ancho que el mínimo es el espectro. La señal
      ocupa 125 k × 1,35 ≈ 170 kHz.
    value: '0.35'
  states: {}
- name: fase_deg
  id: variable_qtgui_range
  parameters:
    comment: |-
      Control de la ventana: fase que gira el canal,
      en grados. La corrige el lazo de Costas de
      cada receptor.
    gui_hint: 0,2,1,2
    label: Fase del canal [°]
    min_len: '150'
    start: '-180'
    step: '1'
    stop: '180'
    value: '0'
  states: {}
- name: formato_trama
  id: variable_header_format_default
  parameters:
    access_code: '0'
    bps: '1'
    comment: |-
      Formato del encabezado de cada trama:
      preámbulo de 64 bits (Access Code 0 = el
      preámbulo estándar de GNU Radio) + longitud
      del payload en 16 bits, escrita 2 veces. Lo
      usan los Protocol Formatter.
    threshold: '0'
  states: {}
- name: guarda
  id: variable
  parameters:
    comment: |-
      Muestras de silencio entre turnos (nadie
      transmite).
    value: '256'
  states: {}
- name: lbl_A
  id: variable_qtgui_label
  parameters:
    comment: |-
      Muestra en la ventana el BER medido por el
      nodo A desde que arrancó.
    formatter: 'lambda x: ''%.2e'' % x'
    gui_hint: 1,3,1,1
    label: 'BER nodo A (acum.): '
    type: real
    value: 10**ber_A_log
  states: {}
- name: lbl_B
  id: variable_qtgui_label
  parameters:
    comment: |-
      Muestra en la ventana el BER medido por el
      nodo B desde que arrancó.
    formatter: 'lambda x: ''%.2e'' % x'
    gui_hint: 1,4,1,1
    label: 'BER nodo B (acum.): '
    type: real
    value: 10**ber_B_log
  states: {}
- name: lbl_ratio
  id: variable_qtgui_label
  parameters:
    comment: |-
      Muestra en la ventana el cociente BER medido /
      BER teórico de cada nodo (cerca de 1 = anda
      como dice la teoría).
    formatter: 'lambda x: ''%.2f | %.2f'' % x'
    gui_hint: 1,5,1,1
    label: 'Medido / teórico (A | B): '
    type: raw
    value: (10**ber_A_log / ber_teo, 10**ber_B_log / ber_teo)
  states: {}
- name: lbl_teo
  id: variable_qtgui_label
  parameters:
    comment: |-
      Muestra en la ventana el BER teórico para el
      Eb/N0 elegido.
    formatter: 'lambda x: ''%.2e'' % x'
    gui_hint: 1,2,1,1
    label: 'BER teórico: '
    type: real
    value: ber_teo
  states: {}
- name: mensaje_A
  id: variable
  parameters:
    comment: Texto que transmite el nodo A en cada trama.
    value: '"Hola, soy el nodo A. Este mensaje viaja por el canal compartido en mi ranura de tiempo (TDD)."'
  states: {}
- name: mensaje_B
  id: variable
  parameters:
    comment: Texto que transmite el nodo B en cada trama.
    value: '"Hola, soy el nodo B. Respondo en la otra ranura: nunca transmitimos los dos al mismo tiempo!!"'
  states: {}
- name: p_qpsk
  id: variable
  parameters:
    comment: |-
      p = Q(raíz(2 Eb/N0)): probabilidad de decidir
      mal un eje de la 4-QAM.
    value: 0.5 * math.erfc(math.sqrt(10**(ebn0_db / 10)))
  states: {}
- name: payload_A
  id: variable
  parameters:
    comment: |-
      El mensaje del nodo A como lista de bytes
      (números de 0 a 255).
    value: list(mensaje_A.encode())
  states: {}
- name: payload_B
  id: variable
  parameters:
    comment: El mensaje del nodo B como lista de bytes.
    value: list(mensaje_B.encode())
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    comment: |-
      Constelación 4-QAM: 4 puntos (±0,707 ± j0,707)
      con código Gray (Symbol Map 0, 1, 3, 2: los
      vecinos difieren en un solo bit). La usan los
      moduladores y los decisores.
    const_points: '[-0.707-0.707j, 0.707-0.707j, +0.707+0.707j, -0.707+0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: ranura
  id: variable
  parameters:
    comment: |-
      Muestras de cada turno de transmisión (2048 =
      512 símbolos; tiene que ser múltiplo de sps).
    value: '2048'
  states: {}
- name: ruido
  id: variable
  parameters:
    comment: |-
      Amplitud del ruido que agrega el canal,
      calculada para que haya el Eb/N0 elegido: la
      señal tiene potencia 1 y 4 muestras por
      símbolo, y Es/N0 = 2 Eb/N0 (2 bits por
      símbolo).
    value: math.sqrt(sps / (2 * 10**(ebn0_db / 10)))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      Muestreo: 500 000 muestras por segundo. Con 4
      muestras por símbolo son 125 000 símbolos/s =
      250 kbit/s mientras un nodo transmite.
    value: '500000'
  states: {}
- name: sps
  id: variable
  parameters:
    comment: Muestras por símbolo (4).
    value: '4'
  states: {}
- name: sync_bw
  id: variable_qtgui_range
  parameters:
    comment: |-
      Control de la ventana: ancho de banda de los
      lazos del sincronismo de símbolo.
    gui_hint: 1,1,1,1
    label: BW sinc. de símbolo
    min_len: '100'
    start: '0.001'
    step: '0.001'
    stop: '0.1'
    value: '0.01'
    widget: counter
  states: {}
- name: umbral
  id: variable
  parameters:
    comment: |-
      Cuántos bits del preámbulo (de 64) pueden
      llegar mal y aun así se acepta la trama.
    value: '12'
  states: {}
- name: ventana
  id: variable
  parameters:
    comment: |-
      Cantidad de bits que se promedian para el BER
      "reciente" (1 millón).
    value: '1000000'
  states: {}
- name: acelerador
  id: blocks_throttle2
  parameters:
    comment: |-
      Frena el flujo a 500 k
      muestras/s (samp_rate): así la
      simulación va a tiempo real y
      no usa toda la CPU.
      Entra: complejos.
      Sale: los mismos complejos, a
        500 k/s.
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: canal_tx_A
  id: virtual_source
  parameters:
    comment: |-
      Toma sin cable la señal
      del nodo A (Virtual Sink
      "tx_A").
      Entra: nada a la vista.
      Sale: complejos.
    stream_id: tx_A
  states: {}
- name: canal_tx_B
  id: virtual_source
  parameters:
    comment: |-
      Toma sin cable la señal
      del nodo B (Virtual Sink
      "tx_B").
      Entra: nada a la vista.
      Sale: complejos.
    stream_id: tx_B
  states: {}
- name: conmutador_rx
  id: blocks_stream_demux
  parameters:
    comment: |-
      Conmutador de recepción:
      reparte las muestras con los
      mismos turnos: la ranura de A
      va a out0 (receptor de B), la
      de B a out2 (receptor de A) y
      las guardas a out1 y out3 (se
      tiran).
      Entra: complejos.
      Sale: 4 salidas de complejos.
    lengths: '[ranura, guarda, ranura, guarda]'
    num_outputs: '4'
    type: complex
  states: {}
- name: fase
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      Gira la constelación la
      fase elegida (multiplica
      por e^(j·fase)).
      Entra: complejos.
      Sale: complejos girados.
    const: cmath.exp(1j * math.radians(fase_deg))
    type: complex
  states: {}
- name: g_canal_const
  id: qtgui_const_sink_x
  parameters:
    alpha1: '0.6'
    comment: |-
      Gráfico (pestaña 1): constelación de las
      muestras del canal, con ruido y sin
      sincronizar.
      Entra: complejos.
      Sale: nada (solo dibuja).
    grid: 'True'
    gui_hint: 'pestanas@0: 1,2,1,1'
    label1: Canal
    legend: 'False'
    name: '"Muestras en el canal (con ruido)"'
    size: '1024'
    type: complex
    xmax: '3'
    xmin: '-3'
    ymax: '3'
    ymin: '-3'
  states: {}
- name: g_canal_esp
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    comment: |-
      Gráfico (pestaña 1): espectro de lo que hay en
      el canal compartido.
      Entra: complejos.
      Sale: nada (solo dibuja).
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 'pestanas@0: 0,2,1,1'
    label: '"Potencia relativa"'
    label1: Canal
    legend: 'False'
    name: '"Espectro en el canal compartido"'
    type: complex
    ymin: '-100'
  states: {}
- name: g_turnos
  id: qtgui_time_sink_x
  parameters:
    comment: |-
      Gráfico (pestaña 1): turnos de A y de B y el
      módulo de la señal en el canal: cada nodo
      transmite solo en su ranura.
      Entra: in0 = turno de A, in1 = turno de B, in2
        = módulo (reales).
      Sale: nada (solo dibuja).
    entags: 'False'
    grid: 'True'
    gui_hint: 'pestanas@0: 0,0,1,2'
    label1: Nodo A transmite
    label2: Nodo B transmite
    label3: '|señal en el canal|'
    name: '"Turnos en el canal compartido"'
    nconnections: '3'
    size: 4 * (ranura + guarda)
    srate: samp_rate
    tr_level: '0.9'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ylabel: Amplitud
    ymax: '2.0'
    ymin: '-0.2'
  states: {}
- name: g_txA
  id: qtgui_time_sink_x
  parameters:
    comment: |-
      Gráfico (pestaña 1): I y Q de la señal que
      transmite el nodo A.
      Entra: complejos.
      Sale: nada (solo dibuja).
    grid: 'True'
    gui_hint: 'pestanas@0: 1,0,1,1'
    label1: I
    label2: Q
    name: '"Señal que transmite el nodo A"'
    size: '200'
    srate: samp_rate
    type: complex
    ylabel: Amplitud
    ymax: '1.25'
    ymin: '-1.25'
  states: {}
- name: g_txA_src
  id: virtual_source
  parameters:
    comment: |-
      Toma sin cable la señal
      del nodo A, para
      graficarla.
      Entra: nada a la vista.
      Sale: complejos.
    stream_id: tx_A
  states: {}
- name: g_txB
  id: qtgui_time_sink_x
  parameters:
    comment: |-
      Gráfico (pestaña 1): I y Q de la señal que
      transmite el nodo B.
      Entra: complejos.
      Sale: nada (solo dibuja).
    grid: 'True'
    gui_hint: 'pestanas@0: 1,1,1,1'
    label1: I
    label2: Q
    name: '"Señal que transmite el nodo B"'
    size: '200'
    srate: samp_rate
    type: complex
    ylabel: Amplitud
    ymax: '1.25'
    ymin: '-1.25'
  states: {}
- name: g_txB_src
  id: virtual_source
  parameters:
    comment: |-
      Toma sin cable la señal
      del nodo B, para
      graficarla.
      Entra: nada a la vista.
      Sale: complejos.
    stream_id: tx_B
  states: {}
- name: guarda_1
  id: blocks_null_sink
  parameters:
    comment: |-
      Tira la guarda que
      sigue al turno de A.
      Entra: complejos.
      Sale: nada.
    type: complex
  states: {}
- name: guarda_3
  id: blocks_null_sink
  parameters:
    comment: |-
      Tira la guarda que
      sigue al turno de B.
      Entra: complejos.
      Sale: nada.
    type: complex
  states: {}
- name: imports
  id: import
  parameters:
    comment: |-
      Módulos de Python que usan las variables y los
      bloques: math y cmath (cuentas con números
      complejos).
    imports: import math, cmath
  states: {}
- name: modulo_canal
  id: blocks_complex_to_mag
  parameters:
    comment: |-
      Calcula el módulo
      |señal| de cada muestra
      del canal, para ver los
      turnos.
      Entra: complejos.
      Sale: reales.
  states: {}
- name: nota_osc
  id: note
  parameters:
    comment: |-
      El desvío de frecuencia (CFO) es la diferencia
      entre los osciladores de A y B: cada receptor
      lo ve con signo opuesto (B: +CFO, A: -CFO).
    note: 'El desvío de frecuencia (CFO) es la diferencia entre los osciladores de A y B: cada receptor lo ve con signo opuesto (B: +CFO, A: -CFO).'
  states: {}
- name: nota_tdd
  id: note
  parameters:
    comment: |-
      CANAL COMPARTIDO (half-duplex por TDD)
      Stream Mux arma los turnos [A | guarda | B |
      guarda]; mientras un nodo no tiene el turno,
      su transmisor espera. Stream Demux es el
      conmutador de recepción: las ranuras de A van
      al receptor de B y las de B al receptor de A
      (nadie se escucha a sí mismo).
    note: 'CANAL COMPARTIDO (half-duplex por TDD): Stream Mux arma los turnos [A | guarda | B | guarda]; mientras un nodo no tiene el turno, su transmisor espera. Stream Demux es el conmutador de recepción: las ranuras de A van al receptor de B y las de B al receptor de A (nadie se escucha a sí mismo).'
  states: {}
- name: nota_tx
  id: note
  parameters:
    comment: |-
      TRANSMISORES
      cada nodo arma sus tramas (mensaje -> CRC-32
      -> preámbulo de 64 bits + longitud ×2) y las
      modula en 4-QAM diferencial con filtro RRC.
    note: 'TRANSMISORES: cada nodo arma sus tramas (mensaje -> CRC-32 -> preámbulo 64 b + longitud x2) y las modula en 4-QAM diferencial con filtro RRC'
  states: {}
- name: osc_rxA
  id: blocks_rotator_cc
  parameters:
    comment: |-
      Oscilador del receptor de A: le agrega a lo
      que transmitió B el desvío -CFO (signo opuesto
      al que ve B).
      Entra: complejos (ranuras de B).
      Sale: complejos con -CFO.
    phase_inc: '-2 * math.pi * cfo_hz / samp_rate'
  states: {}
- name: osc_rxB
  id: blocks_rotator_cc
  parameters:
    comment: |-
      Oscilador del receptor de B: le agrega a lo
      que transmitió A el desvío de frecuencia +CFO
      (la diferencia entre los osciladores de los
      dos nodos).
      Entra: complejos (ranuras de A).
      Sale: complejos con +CFO.
    phase_inc: 2 * math.pi * cfo_hz / samp_rate
  states: {}
- name: pestanas
  id: qtgui_tab_widget
  parameters:
    comment: |-
      Las 3 pestañas de la ventana: 1. Canal
      compartido (TDD), 2. Nodo A recibe (lo que
      transmite B), 3. Nodo B recibe (lo que
      transmite A). Cada gráfico dice en su "GUI
      Hint" en qué pestaña va.
    gui_hint: 2,0,1,6
    label0: 1. Canal compartido (TDD)
    label1: 2. Nodo A recibe (lo que transmite B)
    label2: 3. Nodo B recibe (lo que transmite A)
    num_tabs: '3'
  states: {}
- name: ruido_awgn
  id: analog_noise_source_x
  parameters:
    amp: ruido
    comment: |-
      Genera ruido blanco gaussiano complejo, con la
      amplitud "ruido" (según el Eb/N0 elegido).
      Entra: nada (es una fuente).
      Sale: complejos (ruido).
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: rxA_a_bits
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: |-
      Separa cada número en sus 2 bits (primero el
      más significativo).
      Entra: bytes con 2 bits útiles (0 a 3).
      Sale: bits sueltos (1 bit por byte: 0 o 1).
    k: '2'
  states: {}
- name: rxA_a_bytes
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    comment: |-
      Junta los bits de a 8 para volver a formar
      bytes, respetando dónde empieza cada trama
      (packet_len).
      Entra: bits sueltos (1 por byte).
      Sale: bytes: L_B + 4 por trama (packet_len).
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
    minoutbuf: '70000'
  states: {}
- name: rxA_alinear
  id: blocks_tagged_stream_align
  parameters:
    comment: |-
      Descarta los bits que llegan antes
      de la primera etiqueta
      inicio_trama: así lo recibido
      arranca justo después de un
      preámbulo, alineado con la copia
      del transmisor.
      Entra: bits con etiquetas.
      Sale: bits alineados.
    lengthtagname: '"inicio_trama"'
    type: byte
  states: {}
- name: rxA_archivo
  id: blocks_file_sink
  parameters:
    comment: |-
      Guarda esos mensajes en
      mensajes_recibidos_A.txt (en la carpeta de
      este .grc).
      Entra: bytes.
      Sale: nada (escribe el archivo).
    file: '"mensajes_recibidos_A.txt"'
    type: byte
    unbuffered: 'True'
  states: {}
- name: rxA_ber_ventana
  id: blocks_moving_average_xx
  parameters:
    comment: |-
      Promedia los errores en el último millón de
      bits: da el BER reciente.
      Entra: reales (0 o 1).
      Sale: reales: BER.
    length: ventana
    max_iter: '4000'
    scale: 1.0/ventana
    type: float
  states: {}
- name: rxA_cfo_esperado
  id: analog_sig_source_x
  parameters:
    amp: '-cfo_hz'
    comment: |-
      Genera un valor constante igual
      al desvío que ve el nodo A
      (-CFO), para compararlo con lo
      que estima Costas.
      Entra: nada (es una fuente).
      Sale: reales (Hz).
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate/sps
    type: float
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: rxA_comparar
  id: blocks_xor_xx
  parameters:
    comment: |-
      Compara bit a bit lo recibido con lo
      transmitido (XOR): sale 1 donde hay un error y
      0 donde coinciden.
      Entra: in0 = bits recibidos, in1 = bits
        transmitidos (1 por byte).
      Sale: bytes: 1 = error, 0 = bien.
    type: byte
  states: {}
- name: rxA_costas
  id: digital_costas_loop_cc
  parameters:
    comment: |-
      Lazo de Costas de orden 4: corrige
      la fase y el desvío de frecuencia
      del canal, para que la
      constelación quede quieta en los 4
      puntos.
      Entra: complejos, 1 muestra por
        símbolo.
      Sale: out0 = símbolos corregidos
        (complejos); out1 = frecuencia
        que corrige (rad/símbolo); out2
        = fase y out3 = error (no se
        usan).
    order: '4'
    w: costas_bw
  states: {}
- name: rxA_crc
  id: digital_crc32_bb
  parameters:
    check: 'True'
    comment: |-
      Vuelve a calcular el CRC-32 de
      cada trama: si coincide, la deja
      pasar sin los 4 bytes del CRC;
      si no, la descarta (tenía
      errores).
      Entra: bytes: payload + CRC (L_B
        + 4).
      Sale: bytes: payloads correctos
        (L_B bytes cada uno).
    lengthtagname: '"packet_len"'
    minoutbuf: '70000'
    packed: 'True'
  states: {}
- name: rxA_dec_diferencial
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: |-
      Decodificación diferencial: resta el símbolo
      anterior (módulo 4), o sea, mide el cambio de
      fase. Por eso no importa si Costas quedó
      girado 90°, 180° o 270°.
      Entra: símbolos 0 a 3 (bytes).
      Sale: símbolos 0 a 3 (el cambio de fase).
    modulus: '4'
  states: {}
- name: rxA_decisor
  id: digital_constellation_decoder_cb
  parameters:
    comment: |-
      Decide a cuál de los 4 puntos de la
      constelación está más cerca cada símbolo y
      entrega su número.
      Entra: complejos, 1 por símbolo.
      Sale: bytes con valores 0 a 3 (un símbolo cada
        uno).
    constellation: qpsk
  states: {}
- name: rxA_detector_trama
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: digital.packet_utils.default_access_code
    comment: |-
      Busca en los bits el preámbulo de 64
      bits (acepta hasta "umbral" bits mal),
      lee la longitud (2 copias que tienen que
      coincidir) y entrega solo el payload +
      CRC de cada trama, marcado con
      packet_len.
      Entra: bits sueltos (1 por byte).
      Sale: bits sueltos: 8 × (L_B + 4) por
        trama.
      (En Advanced, Min Output Buffer =
      600000: lugar para la trama más larga,
      así una longitud dañada no traba el
      flujo.)
    minoutbuf: '600000'
    tagname: '"packet_len"'
    threshold: umbral
    type: byte
  states: {}
- name: rxA_entrada
  id: virtual_source
  parameters:
    comment: |-
      Toma sin cable lo que le
      llega al nodo A (Virtual
      Sink "entrada_rx_A"): solo
      las ranuras en que
      transmite B, una tras
      otra.
      Entra: nada a la vista.
      Sale: complejos.
    stream_id: entrada_rx_A
  states: {}
- name: rxA_errores
  id: blocks_char_to_float
  parameters:
    comment: |-
      Pasa cada error (0 o
      1) a número real, para
      promediarlo y
      graficarlo.
      Entra: bytes (0 o 1).
      Sale: reales.
    scale: '1'
  states: {}
- name: rxA_filtro_adaptado
  id: filter_fft_rrc_filter
  parameters:
    alpha: excess_bw
    comment: |-
      Filtro adaptado RRC (igual al del
      transmisor): junto con el del TX
      da un pulso sin interferencia
      entre símbolos y deja afuera la
      mayor parte del ruido.
      Entra: complejos, 4 muestras por
        símbolo.
      Sale: complejos filtrados, 4
        muestras por símbolo.
    decim: '1'
    gain: '1'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: ccc
  states: {}
- name: rxA_frec_hz
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      Pasa la frecuencia de Costas
      de radianes por símbolo a Hz.
      Entra: reales (rad/símbolo).
      Sale: reales (Hz).
    const: samp_rate / sps / (2 * math.pi)
    type: float
  states: {}
- name: rxA_g_ber
  id: qtgui_time_sink_x
  parameters:
    comment: |-
      Gráfico (pestaña 2): log10 del BER medido en
      el último millón de bits (azul) y teórico
      (rojo).
      Entra: in0 = medido, in1 = teórico (reales).
      Sale: nada (solo dibuja).
    entags: 'False'
    grid: 'True'
    gui_hint: 'pestanas@1: 1,2,1,1'
    label1: Medido (último Mbit)
    label2: Teórico
    name: '"log10(BER): medido vs teórico"'
    nconnections: '2'
    size: '500'
    srate: samp_rate/sps*2/1000
    type: float
    ylabel: log10(BER)
    ymax: '0'
    ymin: '-6'
  states: {}
- name: rxA_g_bits
  id: qtgui_time_sink_x
  parameters:
    comment: |-
      Gráfico (pestaña 2): bits recibidos, bits
      transmitidos (corridos +1,5) y errores (1 =
      error).
      Entra: in0 = RX, in1 = TX + 1,5, in2 = errores
        (reales).
      Sale: nada (solo dibuja).
    entags: 'False'
    grid: 'True'
    gui_hint: 'pestanas@1: 1,0,1,1'
    label1: RX
    label2: TX (+1,5)
    label3: Errores
    name: '"Bits RX vs TX (+1,5) y errores"'
    nconnections: '3'
    size: '200'
    srate: samp_rate/sps*2
    type: float
    ylabel: Bit
    ymax: '4'
  states: {}
- name: rxA_g_const
  id: qtgui_const_sink_x
  parameters:
    alpha1: '0.6'
    alpha2: '0.6'
    comment: |-
      Gráfico (pestaña 2): constelación antes (azul)
      y después (rojo) de Costas. Después tienen que
      verse 4 grupos de puntos quietos.
      Entra: in0 = antes, in1 = después (complejos,
        1 por símbolo).
      Sale: nada (solo dibuja).
    grid: 'True'
    gui_hint: 'pestanas@1: 0,1,1,1'
    label1: Antes
    label2: Después
    name: '"Constelación antes y después de Costas"'
    nconnections: '2'
    size: '1024'
    type: complex
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: rxA_g_frec
  id: qtgui_time_sink_x
  parameters:
    comment: |-
      Gráfico (pestaña 2): frecuencia que corrige
      Costas (azul) y desvío esperado (rojo): cuando
      Costas se engancha, coinciden.
      Entra: in0 = Costas, in1 = esperado (reales,
        Hz).
      Sale: nada (solo dibuja).
    entags: 'False'
    grid: 'True'
    gui_hint: 'pestanas@1: 0,2,1,1'
    label1: Costas
    label2: CFO (-Δf)
    name: '"Frecuencia de Costas vs CFO [Hz]"'
    nconnections: '2'
    size: '2000'
    srate: samp_rate/sps
    type: float
    ylabel: Hz
    ymax: '1100'
    ymin: '-1100'
  states: {}
- name: rxA_g_ojo
  id: qtgui_eye_sink_x
  parameters:
    alpha1: '0.5'
    comment: |-
      Gráfico (pestaña 2): diagrama de ojo de I
      (antes del sincronismo y de Costas): el "ojo"
      abierto es el mejor instante para muestrear.
      Entra: reales.
      Sale: nada (solo dibuja).
    entags: 'False'
    grid: 'True'
    gui_hint: 'pestanas@1: 0,0,1,1'
    label1: Ojo de la componente I (antes de Costas)
    samp_per_symbol: 4*sps
    size: '2048'
    srate: 4*samp_rate
    type: float
    ylabel: '"Amplitud"'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: rxA_g_payload
  id: qtgui_time_sink_x
  parameters:
    comment: |-
      Gráfico (pestaña 2): bits que
      entrega el detector (payload +
      CRC de cada trama).
      Entra: reales.
      Sale: nada (solo dibuja).
    grid: 'True'
    gui_hint: 'pestanas@1: 1,1,1,1'
    label1: Payload + CRC
    legend: 'False'
    name: '"Payload del detector de tramas"'
    size: 2 * 8 * (L_B + 4)
    srate: samp_rate/sps*2
    type: float
    ylabel: Bit
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: rxA_log_ber
  id: blocks_nlog10_ff
  parameters:
    comment: |-
      Calcula el log10 del BER.
      Entra: reales.
      Sale: reales: log10(BER).
    k: '0'
  states: {}
- name: rxA_log_teo
  id: analog_sig_source_x
  parameters:
    amp: math.log10(ber_teo)
    comment: |-
      Genera un valor constante
      igual al log10 del BER
      teórico, para el gráfico.
      Entra: nada (es una fuente).
      Sale: reales.
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate/sps*2/1000
    type: float
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: rxA_mapa_gray
  id: digital_map_bb
  parameters:
    comment: |-
      Deshace el código Gray: cambia cada símbolo
      por los 2 bits que mandó el transmisor (0->0,
      1->1, 2->3, 3->2).
      Entra: símbolos 0 a 3 (bytes).
      Sale: números 0 a 3 = 2 bits de datos (bytes).
    map: '[0, 1, 3, 2]'
  states: {}
- name: rxA_marca_preambulo
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: digital.packet_utils.default_access_code
    comment: |-
      Busca el preámbulo en los bits y pone una
      etiqueta "inicio_trama" donde termina. No
      quita nada.
      Entra: bits sueltos (1 por byte).
      Sale: los mismos bits, con etiquetas
        inicio_trama.
    tagname: '"inicio_trama"'
    threshold: umbral
    type: byte
  states: {}
- name: rxA_medidor_ber
  id: fec_ber_bf
  parameters:
    comment: |-
      Cuenta los bits
      distintos entre sus dos
      entradas desde el
      comienzo y entrega el
      log10 del BER acumulado
      (con 0 errores da
      -infinito).
      Entra: in0 = bytes
        recibidos, in1 = bytes
        transmitidos.
      Sale: reales: log10(BER
        acumulado).
    test_mode: 'False'
  states: {}
- name: rxA_nota
  id: note
  parameters:
    comment: |-
      RECEPTOR DEL NODO A (recibe lo que transmite
      B)
      filtro adaptado -> sincronismo de símbolo ->
      Costas -> decisión -> decodificación
      diferencial -> tramas (CRC-32) y BER
    note: 'RECEPTOR DEL NODO A (recibe lo que transmite B): filtro adaptado -> sincronismo de símbolo -> Costas -> decisión -> decodificación diferencial -> tramas (CRC-32) y BER'
  states: {}
- name: rxA_ojo_interp
  id: rational_resampler_xxx
  parameters:
    comment: |-
      Agrega 3 muestras entre cada par (interpola ×
      4: 16 por símbolo) solo para que el diagrama
      de ojo se vea suave.
      Entra: complejos.
      Sale: complejos (4 veces más muestras).
    decim: '1'
    interp: '4'
    type: ccc
  states: {}
- name: rxA_ojo_re
  id: blocks_complex_to_real
  parameters:
    comment: |-
      Se queda con la parte real (I), para el
      diagrama de ojo.
      Entra: complejos.
      Sale: reales.
  states: {}
- name: rxA_payload_f
  id: blocks_char_to_float
  parameters:
    comment: |-
      Pasa cada bit a número real, para el gráfico.
      Entra: bits sueltos (bytes 0 o 1).
      Sale: reales.
    scale: '1'
  states: {}
- name: rxA_ref_a_paquetes
  id: blocks_stream_to_tagged_stream
  parameters:
    comment: |-
      Copia del transmisor: corta en
      grupos de L_B bytes marcados con
      packet_len.
      Entra: bytes.
      Sale: bytes en grupos marcados.
    len_tag_key: '"packet_len"'
    packet_len: L_B
    type: byte
  states: {}
- name: rxA_ref_bit_f
  id: blocks_char_to_float
  parameters:
    comment: |-
      Pasa los bits transmitidos a números reales,
      para el gráfico.
      Entra: bits sueltos.
      Sale: reales.
    scale: '1'
  states: {}
- name: rxA_ref_bits
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: |-
      Separa cada byte de las tramas de referencia
      en sus 8 bits (primero el más significativo).
      Entra: bytes.
      Sale: bits sueltos (1 por byte).
    k: '8'
  states: {}
- name: rxA_ref_bytes
  id: blocks_repack_bits_bb
  parameters:
    comment: |-
      Junta los bits transmitidos de a 8, como los
      recibidos.
      Entra: bits sueltos.
      Sale: bytes.
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: rxA_ref_crc
  id: digital_crc32_bb
  parameters:
    check: 'False'
    comment: |-
      Copia del transmisor: agrega el CRC-32 de cada
      payload.
      Entra: bytes: payload (packet_len).
      Sale: bytes: payload + CRC.
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: rxA_ref_desplazar
  id: blocks_add_const_vxx
  parameters:
    comment: |-
      Suma 1,5 a los bits transmitidos, para verlos
      separados de los recibidos en el gráfico.
      Entra: reales.
      Sale: reales (1,5 o 2,5).
    const: '1.5'
    type: float
  states: {}
- name: rxA_ref_encabezado
  id: digital_protocol_formatter_bb
  parameters:
    comment: |-
      Copia del transmisor: arma el
      encabezado (preámbulo + longitud
      ×2).
      Entra: bytes: payload + CRC.
      Sale: bytes: encabezado (12
        bytes).
    format: formato_trama
    len_tag_key: '"packet_len"'
  states: {}
- name: rxA_ref_fuente
  id: blocks_vector_source_x
  parameters:
    comment: |-
      Copia del transmisor, para saber qué bits se
      mandaron: entrega una y otra vez el mensaje
      del nodo B (lista "payload_B").
      Entra: nada (es una fuente).
      Sale: bytes.
    repeat: 'True'
    type: byte
    vector: payload_B
  states: {}
- name: rxA_ref_saltar_preambulo
  id: blocks_skiphead
  parameters:
    comment: |-
      Saltea los primeros 64 bits (el
      primer preámbulo), para arrancar
      en el mismo lugar que lo recibido
      después de "alinear".
      Entra: bits sueltos.
      Sale: los mismos bits, sin los 64
        primeros.
    num_items: '64'
    type: byte
  states: {}
- name: rxA_ref_trama
  id: blocks_tagged_stream_mux
  parameters:
    comment: |-
      Copia del transmisor: pone el
      encabezado delante del
      payload.
      Entra: in0 = encabezado, in1 =
        payload + CRC.
      Sale: bytes: tramas completas.
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: rxA_rx_bit_f
  id: blocks_char_to_float
  parameters:
    comment: |-
      Pasa los bits recibidos (ya alineados) a
      números reales, para el gráfico.
      Entra: bits sueltos.
      Sale: reales.
    scale: '1'
  states: {}
- name: rxA_rx_bytes
  id: blocks_repack_bits_bb
  parameters:
    comment: |-
      Junta los bits recibidos de a 8, sin mirar
      etiquetas: el medidor de BER compara bytes.
      Entra: bits sueltos.
      Sale: bytes.
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: rxA_sinc_null_1
  id: blocks_null_sink
  parameters:
    comment: |-
      Descarta el error del
      sincronismo de símbolo (no se
      usa).
      Entra: reales.
      Sale: nada.
    type: float
  states: {}
- name: rxA_sinc_null_2
  id: blocks_null_sink
  parameters:
    comment: |-
      Descarta el período
      instantáneo del sincronismo de
      símbolo (no se usa).
      Entra: reales.
      Sale: nada.
    type: float
  states: {}
- name: rxA_sinc_null_3
  id: blocks_null_sink
  parameters:
    comment: |-
      Descarta el período promedio
      del sincronismo de símbolo (no
      se usa).
      Entra: reales.
      Sale: nada.
    type: float
  states: {}
- name: rxA_sinc_simbolo
  id: digital_symbol_sync_xx
  parameters:
    comment: |-
      Sincronismo de símbolo: encuentra el mejor
      instante para muestrear cada símbolo (el
      centro del ojo) y entrega una muestra por
      símbolo.
      Entra: complejos, 4 muestras por símbolo.
      Sale: out0 = complejos, 1 muestra por símbolo;
        out1 = error, out2 = período instantáneo y
        out3 = período promedio del reloj (reales).
    damping: '1.0'
    loop_bw: sync_bw
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: rxA_sonda_ber
  id: blocks_probe_signal_x
  parameters:
    comment: |-
      Guarda el último valor que le llega, para que
      la variable ber_A_log lo pueda leer.
      Entra: reales.
      Sale: nada (se lee con un Function Probe).
    type: float
  states: {}
- name: rxA_submuestreo
  id: blocks_keep_one_in_n
  parameters:
    comment: |-
      Se queda con 1 de cada 1000 valores, para que
      el gráfico no tenga que dibujar tantos.
      Entra: reales.
      Sale: reales (1000 veces menos).
    n: '1000'
    type: float
  states: {}
- name: rxA_una_de_cien
  id: blocks_keep_m_in_n
  parameters:
    comment: |-
      De cada 100 mensajes correctos se queda con 1
      (para no llenar el disco).
      Entra: bytes: mensajes correctos (L_B bytes
        cada uno).
      Sale: bytes: 1 mensaje de cada 100.
    m: L_B
    n: 100*L_B
    offset: '0'
    type: byte
  states: {}
- name: rxA_vs_entrada
  id: virtual_sink
  parameters:
    comment: |-
      Conexión sin cable: lo que le llega al nodo A
      sigue en el Virtual Source "entrada_rx_A"
      (receptor de A).
      Entra: complejos.
      Sale: nada a la vista.
    stream_id: entrada_rx_A
  states: {}
- name: rxB_a_bits
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: |-
      Separa cada número en sus 2 bits (primero el
      más significativo).
      Entra: bytes con 2 bits útiles (0 a 3).
      Sale: bits sueltos (1 bit por byte: 0 o 1).
    k: '2'
  states: {}
- name: rxB_a_bytes
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    comment: |-
      Junta los bits de a 8 para volver a formar
      bytes, respetando dónde empieza cada trama
      (packet_len).
      Entra: bits sueltos (1 por byte).
      Sale: bytes: L_A + 4 por trama (packet_len).
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
    minoutbuf: '70000'
  states: {}
- name: rxB_alinear
  id: blocks_tagged_stream_align
  parameters:
    comment: |-
      Descarta los bits que llegan antes
      de la primera etiqueta
      inicio_trama: así lo recibido
      arranca justo después de un
      preámbulo, alineado con la copia
      del transmisor.
      Entra: bits con etiquetas.
      Sale: bits alineados.
    lengthtagname: '"inicio_trama"'
    type: byte
  states: {}
- name: rxB_archivo
  id: blocks_file_sink
  parameters:
    comment: |-
      Guarda esos mensajes en
      mensajes_recibidos_B.txt (en la carpeta de
      este .grc).
      Entra: bytes.
      Sale: nada (escribe el archivo).
    file: '"mensajes_recibidos_B.txt"'
    type: byte
    unbuffered: 'True'
  states: {}
- name: rxB_ber_ventana
  id: blocks_moving_average_xx
  parameters:
    comment: |-
      Promedia los errores en el último millón de
      bits: da el BER reciente.
      Entra: reales (0 o 1).
      Sale: reales: BER.
    length: ventana
    max_iter: '4000'
    scale: 1.0/ventana
    type: float
  states: {}
- name: rxB_cfo_esperado
  id: analog_sig_source_x
  parameters:
    amp: cfo_hz
    comment: |-
      Genera un valor constante igual
      al desvío que ve el nodo B
      (+CFO), para compararlo con lo
      que estima Costas.
      Entra: nada (es una fuente).
      Sale: reales (Hz).
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate/sps
    type: float
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: rxB_comparar
  id: blocks_xor_xx
  parameters:
    comment: |-
      Compara bit a bit lo recibido con lo
      transmitido (XOR): sale 1 donde hay un error y
      0 donde coinciden.
      Entra: in0 = bits recibidos, in1 = bits
        transmitidos (1 por byte).
      Sale: bytes: 1 = error, 0 = bien.
    type: byte
  states: {}
- name: rxB_costas
  id: digital_costas_loop_cc
  parameters:
    comment: |-
      Lazo de Costas de orden 4: corrige
      la fase y el desvío de frecuencia
      del canal, para que la
      constelación quede quieta en los 4
      puntos.
      Entra: complejos, 1 muestra por
        símbolo.
      Sale: out0 = símbolos corregidos
        (complejos); out1 = frecuencia
        que corrige (rad/símbolo); out2
        = fase y out3 = error (no se
        usan).
    order: '4'
    w: costas_bw
  states: {}
- name: rxB_crc
  id: digital_crc32_bb
  parameters:
    check: 'True'
    comment: |-
      Vuelve a calcular el CRC-32 de
      cada trama: si coincide, la deja
      pasar sin los 4 bytes del CRC;
      si no, la descarta (tenía
      errores).
      Entra: bytes: payload + CRC (L_A
        + 4).
      Sale: bytes: payloads correctos
        (L_A bytes cada uno).
    lengthtagname: '"packet_len"'
    minoutbuf: '70000'
    packed: 'True'
  states: {}
- name: rxB_dec_diferencial
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: |-
      Decodificación diferencial: resta el símbolo
      anterior (módulo 4), o sea, mide el cambio de
      fase. Por eso no importa si Costas quedó
      girado 90°, 180° o 270°.
      Entra: símbolos 0 a 3 (bytes).
      Sale: símbolos 0 a 3 (el cambio de fase).
    modulus: '4'
  states: {}
- name: rxB_decisor
  id: digital_constellation_decoder_cb
  parameters:
    comment: |-
      Decide a cuál de los 4 puntos de la
      constelación está más cerca cada símbolo y
      entrega su número.
      Entra: complejos, 1 por símbolo.
      Sale: bytes con valores 0 a 3 (un símbolo cada
        uno).
    constellation: qpsk
  states: {}
- name: rxB_detector_trama
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: digital.packet_utils.default_access_code
    comment: |-
      Busca en los bits el preámbulo de 64
      bits (acepta hasta "umbral" bits mal),
      lee la longitud (2 copias que tienen que
      coincidir) y entrega solo el payload +
      CRC de cada trama, marcado con
      packet_len.
      Entra: bits sueltos (1 por byte).
      Sale: bits sueltos: 8 × (L_A + 4) por
        trama.
      (En Advanced, Min Output Buffer =
      600000: lugar para la trama más larga,
      así una longitud dañada no traba el
      flujo.)
    minoutbuf: '600000'
    tagname: '"packet_len"'
    threshold: umbral
    type: byte
  states: {}
- name: rxB_entrada
  id: virtual_source
  parameters:
    comment: |-
      Toma sin cable lo que le
      llega al nodo B (Virtual
      Sink "entrada_rx_B"): solo
      las ranuras en que
      transmite A, una tras
      otra.
      Entra: nada a la vista.
      Sale: complejos.
    stream_id: entrada_rx_B
  states: {}
- name: rxB_errores
  id: blocks_char_to_float
  parameters:
    comment: |-
      Pasa cada error (0 o
      1) a número real, para
      promediarlo y
      graficarlo.
      Entra: bytes (0 o 1).
      Sale: reales.
    scale: '1'
  states: {}
- name: rxB_filtro_adaptado
  id: filter_fft_rrc_filter
  parameters:
    alpha: excess_bw
    comment: |-
      Filtro adaptado RRC (igual al del
      transmisor): junto con el del TX
      da un pulso sin interferencia
      entre símbolos y deja afuera la
      mayor parte del ruido.
      Entra: complejos, 4 muestras por
        símbolo.
      Sale: complejos filtrados, 4
        muestras por símbolo.
    decim: '1'
    gain: '1'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: ccc
  states: {}
- name: rxB_frec_hz
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      Pasa la frecuencia de Costas
      de radianes por símbolo a Hz.
      Entra: reales (rad/símbolo).
      Sale: reales (Hz).
    const: samp_rate / sps / (2 * math.pi)
    type: float
  states: {}
- name: rxB_g_ber
  id: qtgui_time_sink_x
  parameters:
    comment: |-
      Gráfico (pestaña 3): log10 del BER medido en
      el último millón de bits (azul) y teórico
      (rojo).
      Entra: in0 = medido, in1 = teórico (reales).
      Sale: nada (solo dibuja).
    entags: 'False'
    grid: 'True'
    gui_hint: 'pestanas@2: 1,2,1,1'
    label1: Medido (último Mbit)
    label2: Teórico
    name: '"log10(BER): medido vs teórico"'
    nconnections: '2'
    size: '500'
    srate: samp_rate/sps*2/1000
    type: float
    ylabel: log10(BER)
    ymax: '0'
    ymin: '-6'
  states: {}
- name: rxB_g_bits
  id: qtgui_time_sink_x
  parameters:
    comment: |-
      Gráfico (pestaña 3): bits recibidos, bits
      transmitidos (corridos +1,5) y errores (1 =
      error).
      Entra: in0 = RX, in1 = TX + 1,5, in2 = errores
        (reales).
      Sale: nada (solo dibuja).
    entags: 'False'
    grid: 'True'
    gui_hint: 'pestanas@2: 1,0,1,1'
    label1: RX
    label2: TX (+1,5)
    label3: Errores
    name: '"Bits RX vs TX (+1,5) y errores"'
    nconnections: '3'
    size: '200'
    srate: samp_rate/sps*2
    type: float
    ylabel: Bit
    ymax: '4'
  states: {}
- name: rxB_g_const
  id: qtgui_const_sink_x
  parameters:
    alpha1: '0.6'
    alpha2: '0.6'
    comment: |-
      Gráfico (pestaña 3): constelación antes (azul)
      y después (rojo) de Costas. Después tienen que
      verse 4 grupos de puntos quietos.
      Entra: in0 = antes, in1 = después (complejos,
        1 por símbolo).
      Sale: nada (solo dibuja).
    grid: 'True'
    gui_hint: 'pestanas@2: 0,1,1,1'
    label1: Antes
    label2: Después
    name: '"Constelación antes y después de Costas"'
    nconnections: '2'
    size: '1024'
    type: complex
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: rxB_g_frec
  id: qtgui_time_sink_x
  parameters:
    comment: |-
      Gráfico (pestaña 3): frecuencia que corrige
      Costas (azul) y desvío esperado (rojo): cuando
      Costas se engancha, coinciden.
      Entra: in0 = Costas, in1 = esperado (reales,
        Hz).
      Sale: nada (solo dibuja).
    entags: 'False'
    grid: 'True'
    gui_hint: 'pestanas@2: 0,2,1,1'
    label1: Costas
    label2: CFO (+Δf)
    name: '"Frecuencia de Costas vs CFO [Hz]"'
    nconnections: '2'
    size: '2000'
    srate: samp_rate/sps
    type: float
    ylabel: Hz
    ymax: '1100'
    ymin: '-1100'
  states: {}
- name: rxB_g_ojo
  id: qtgui_eye_sink_x
  parameters:
    alpha1: '0.5'
    comment: |-
      Gráfico (pestaña 3): diagrama de ojo de I
      (antes del sincronismo y de Costas): el "ojo"
      abierto es el mejor instante para muestrear.
      Entra: reales.
      Sale: nada (solo dibuja).
    entags: 'False'
    grid: 'True'
    gui_hint: 'pestanas@2: 0,0,1,1'
    label1: Ojo de la componente I (antes de Costas)
    samp_per_symbol: 4*sps
    size: '2048'
    srate: 4*samp_rate
    type: float
    ylabel: '"Amplitud"'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: rxB_g_payload
  id: qtgui_time_sink_x
  parameters:
    comment: |-
      Gráfico (pestaña 3): bits que
      entrega el detector (payload +
      CRC de cada trama).
      Entra: reales.
      Sale: nada (solo dibuja).
    grid: 'True'
    gui_hint: 'pestanas@2: 1,1,1,1'
    label1: Payload + CRC
    legend: 'False'
    name: '"Payload del detector de tramas"'
    size: 2 * 8 * (L_A + 4)
    srate: samp_rate/sps*2
    type: float
    ylabel: Bit
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: rxB_log_ber
  id: blocks_nlog10_ff
  parameters:
    comment: |-
      Calcula el log10 del BER.
      Entra: reales.
      Sale: reales: log10(BER).
    k: '0'
  states: {}
- name: rxB_log_teo
  id: analog_sig_source_x
  parameters:
    amp: math.log10(ber_teo)
    comment: |-
      Genera un valor constante
      igual al log10 del BER
      teórico, para el gráfico.
      Entra: nada (es una fuente).
      Sale: reales.
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate/sps*2/1000
    type: float
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: rxB_mapa_gray
  id: digital_map_bb
  parameters:
    comment: |-
      Deshace el código Gray: cambia cada símbolo
      por los 2 bits que mandó el transmisor (0->0,
      1->1, 2->3, 3->2).
      Entra: símbolos 0 a 3 (bytes).
      Sale: números 0 a 3 = 2 bits de datos (bytes).
    map: '[0, 1, 3, 2]'
  states: {}
- name: rxB_marca_preambulo
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: digital.packet_utils.default_access_code
    comment: |-
      Busca el preámbulo en los bits y pone una
      etiqueta "inicio_trama" donde termina. No
      quita nada.
      Entra: bits sueltos (1 por byte).
      Sale: los mismos bits, con etiquetas
        inicio_trama.
    tagname: '"inicio_trama"'
    threshold: umbral
    type: byte
  states: {}
- name: rxB_medidor_ber
  id: fec_ber_bf
  parameters:
    comment: |-
      Cuenta los bits
      distintos entre sus dos
      entradas desde el
      comienzo y entrega el
      log10 del BER acumulado
      (con 0 errores da
      -infinito).
      Entra: in0 = bytes
        recibidos, in1 = bytes
        transmitidos.
      Sale: reales: log10(BER
        acumulado).
    test_mode: 'False'
  states: {}
- name: rxB_nota
  id: note
  parameters:
    comment: |-
      RECEPTOR DEL NODO B (recibe lo que transmite
      A)
      filtro adaptado -> sincronismo de símbolo ->
      Costas -> decisión -> decodificación
      diferencial -> tramas (CRC-32) y BER
    note: 'RECEPTOR DEL NODO B (recibe lo que transmite A): filtro adaptado -> sincronismo de símbolo -> Costas -> decisión -> decodificación diferencial -> tramas (CRC-32) y BER'
  states: {}
- name: rxB_ojo_interp
  id: rational_resampler_xxx
  parameters:
    comment: |-
      Agrega 3 muestras entre cada par (interpola ×
      4: 16 por símbolo) solo para que el diagrama
      de ojo se vea suave.
      Entra: complejos.
      Sale: complejos (4 veces más muestras).
    decim: '1'
    interp: '4'
    type: ccc
  states: {}
- name: rxB_ojo_re
  id: blocks_complex_to_real
  parameters:
    comment: |-
      Se queda con la parte real (I), para el
      diagrama de ojo.
      Entra: complejos.
      Sale: reales.
  states: {}
- name: rxB_payload_f
  id: blocks_char_to_float
  parameters:
    comment: |-
      Pasa cada bit a número real, para el gráfico.
      Entra: bits sueltos (bytes 0 o 1).
      Sale: reales.
    scale: '1'
  states: {}
- name: rxB_ref_a_paquetes
  id: blocks_stream_to_tagged_stream
  parameters:
    comment: |-
      Copia del transmisor: corta en
      grupos de L_A bytes marcados con
      packet_len.
      Entra: bytes.
      Sale: bytes en grupos marcados.
    len_tag_key: '"packet_len"'
    packet_len: L_A
    type: byte
  states: {}
- name: rxB_ref_bit_f
  id: blocks_char_to_float
  parameters:
    comment: |-
      Pasa los bits transmitidos a números reales,
      para el gráfico.
      Entra: bits sueltos.
      Sale: reales.
    scale: '1'
  states: {}
- name: rxB_ref_bits
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: |-
      Separa cada byte de las tramas de referencia
      en sus 8 bits (primero el más significativo).
      Entra: bytes.
      Sale: bits sueltos (1 por byte).
    k: '8'
  states: {}
- name: rxB_ref_bytes
  id: blocks_repack_bits_bb
  parameters:
    comment: |-
      Junta los bits transmitidos de a 8, como los
      recibidos.
      Entra: bits sueltos.
      Sale: bytes.
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: rxB_ref_crc
  id: digital_crc32_bb
  parameters:
    check: 'False'
    comment: |-
      Copia del transmisor: agrega el CRC-32 de cada
      payload.
      Entra: bytes: payload (packet_len).
      Sale: bytes: payload + CRC.
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: rxB_ref_desplazar
  id: blocks_add_const_vxx
  parameters:
    comment: |-
      Suma 1,5 a los bits transmitidos, para verlos
      separados de los recibidos en el gráfico.
      Entra: reales.
      Sale: reales (1,5 o 2,5).
    const: '1.5'
    type: float
  states: {}
- name: rxB_ref_encabezado
  id: digital_protocol_formatter_bb
  parameters:
    comment: |-
      Copia del transmisor: arma el
      encabezado (preámbulo + longitud
      ×2).
      Entra: bytes: payload + CRC.
      Sale: bytes: encabezado (12
        bytes).
    format: formato_trama
    len_tag_key: '"packet_len"'
  states: {}
- name: rxB_ref_fuente
  id: blocks_vector_source_x
  parameters:
    comment: |-
      Copia del transmisor, para saber qué bits se
      mandaron: entrega una y otra vez el mensaje
      del nodo A (lista "payload_A").
      Entra: nada (es una fuente).
      Sale: bytes.
    repeat: 'True'
    type: byte
    vector: payload_A
  states: {}
- name: rxB_ref_saltar_preambulo
  id: blocks_skiphead
  parameters:
    comment: |-
      Saltea los primeros 64 bits (el
      primer preámbulo), para arrancar
      en el mismo lugar que lo recibido
      después de "alinear".
      Entra: bits sueltos.
      Sale: los mismos bits, sin los 64
        primeros.
    num_items: '64'
    type: byte
  states: {}
- name: rxB_ref_trama
  id: blocks_tagged_stream_mux
  parameters:
    comment: |-
      Copia del transmisor: pone el
      encabezado delante del
      payload.
      Entra: in0 = encabezado, in1 =
        payload + CRC.
      Sale: bytes: tramas completas.
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: rxB_rx_bit_f
  id: blocks_char_to_float
  parameters:
    comment: |-
      Pasa los bits recibidos (ya alineados) a
      números reales, para el gráfico.
      Entra: bits sueltos.
      Sale: reales.
    scale: '1'
  states: {}
- name: rxB_rx_bytes
  id: blocks_repack_bits_bb
  parameters:
    comment: |-
      Junta los bits recibidos de a 8, sin mirar
      etiquetas: el medidor de BER compara bytes.
      Entra: bits sueltos.
      Sale: bytes.
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: rxB_sinc_null_1
  id: blocks_null_sink
  parameters:
    comment: |-
      Descarta el error del
      sincronismo de símbolo (no se
      usa).
      Entra: reales.
      Sale: nada.
    type: float
  states: {}
- name: rxB_sinc_null_2
  id: blocks_null_sink
  parameters:
    comment: |-
      Descarta el período
      instantáneo del sincronismo de
      símbolo (no se usa).
      Entra: reales.
      Sale: nada.
    type: float
  states: {}
- name: rxB_sinc_null_3
  id: blocks_null_sink
  parameters:
    comment: |-
      Descarta el período promedio
      del sincronismo de símbolo (no
      se usa).
      Entra: reales.
      Sale: nada.
    type: float
  states: {}
- name: rxB_sinc_simbolo
  id: digital_symbol_sync_xx
  parameters:
    comment: |-
      Sincronismo de símbolo: encuentra el mejor
      instante para muestrear cada símbolo (el
      centro del ojo) y entrega una muestra por
      símbolo.
      Entra: complejos, 4 muestras por símbolo.
      Sale: out0 = complejos, 1 muestra por símbolo;
        out1 = error, out2 = período instantáneo y
        out3 = período promedio del reloj (reales).
    damping: '1.0'
    loop_bw: sync_bw
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: rxB_sonda_ber
  id: blocks_probe_signal_x
  parameters:
    comment: |-
      Guarda el último valor que le llega, para que
      la variable ber_B_log lo pueda leer.
      Entra: reales.
      Sale: nada (se lee con un Function Probe).
    type: float
  states: {}
- name: rxB_submuestreo
  id: blocks_keep_one_in_n
  parameters:
    comment: |-
      Se queda con 1 de cada 1000 valores, para que
      el gráfico no tenga que dibujar tantos.
      Entra: reales.
      Sale: reales (1000 veces menos).
    n: '1000'
    type: float
  states: {}
- name: rxB_una_de_cien
  id: blocks_keep_m_in_n
  parameters:
    comment: |-
      De cada 100 mensajes correctos se queda con 1
      (para no llenar el disco).
      Entra: bytes: mensajes correctos (L_A bytes
        cada uno).
      Sale: bytes: 1 mensaje de cada 100.
    m: L_A
    n: 100*L_A
    offset: '0'
    type: byte
  states: {}
- name: rxB_vs_entrada
  id: virtual_sink
  parameters:
    comment: |-
      Conexión sin cable: lo que le llega al nodo B
      sigue en el Virtual Source "entrada_rx_B"
      (receptor de B).
      Entra: complejos.
      Sale: nada a la vista.
    stream_id: entrada_rx_B
  states: {}
- name: silencio_1
  id: blocks_null_source
  parameters:
    comment: |-
      Entrega ceros: el
      silencio de la guarda
      después del turno de A.
      Entra: nada (es una
        fuente).
      Sale: complejos (0).
    type: complex
  states: {}
- name: silencio_3
  id: blocks_null_source
  parameters:
    comment: |-
      Entrega ceros: el
      silencio de la guarda
      después del turno de B.
      Entra: nada (es una
        fuente).
      Sale: complejos (0).
    type: complex
  states: {}
- name: suma_ruido
  id: blocks_add_xx
  parameters:
    comment: |-
      Suma la señal y el
      ruido: es lo que hay
      en el canal
      compartido.
      Entra: in0 = señal,
        in1 = ruido
        (complejos).
      Sale: complejos.
    type: complex
  states: {}
- name: turno_A
  id: blocks_vector_source_x
  parameters:
    comment: |-
      Entrega 1,8 durante el turno
      de A y 0 el resto, para
      marcarlo en el gráfico.
      Entra: nada (es una fuente).
      Sale: reales.
    repeat: 'True'
    type: float
    vector: '[1.8] * ranura + [0.0] * (guarda + ranura + guarda)'
  states: {}
- name: turno_B
  id: blocks_vector_source_x
  parameters:
    comment: |-
      Entrega 1,8 durante el turno
      de B y 0 el resto.
      Entra: nada (es una fuente).
      Sale: reales.
    repeat: 'True'
    type: float
    vector: '[0.0] * (ranura + guarda) + [1.8] * ranura + [0.0] * guarda'
  states: {}
- name: turnos
  id: blocks_stream_mux
  parameters:
    comment: |-
      Arma los turnos: toma "ranura"
      muestras de A, "guarda" de
      silencio, "ranura" de B y "guarda"
      de silencio, y repite. Cuenta
      muestras: no mira etiquetas.
      Entra: in0 = A, in1 = silencio,
        in2 = B, in3 = silencio
        (complejos).
      Sale: complejos: [A | guarda | B |
        guarda] ...
    lengths: '[ranura, guarda, ranura, guarda]'
    num_inputs: '4'
    type: complex
  states: {}
- name: txA_a_paquetes
  id: blocks_stream_to_tagged_stream
  parameters:
    comment: |-
      Corta el flujo en grupos de L_A
      bytes (uno por trama) y marca el
      comienzo de cada grupo con la
      etiqueta packet_len. Así los bloques
      siguientes saben dónde empieza y
      termina cada trama.
      Entra: bytes sin marcas.
      Sale: los mismos bytes, en grupos de
        L_A marcados con packet_len.
    len_tag_key: '"packet_len"'
    packet_len: L_A
    type: byte
  states: {}
- name: txA_crc
  id: digital_crc32_bb
  parameters:
    check: 'False'
    comment: |-
      Calcula el CRC-32 de cada payload y se lo
      agrega al final (4 bytes). El receptor lo
      vuelve a calcular para descartar las tramas
      con errores.
      Entra: bytes: payload de L_A bytes
        (packet_len).
      Sale: bytes: payload + CRC = L_A + 4 bytes.
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: txA_encabezado
  id: digital_protocol_formatter_bb
  parameters:
    comment: |-
      Arma el encabezado de cada trama
      con el formato "formato_trama":
      preámbulo de 64 bits + longitud (2
      veces). Solo produce el
      encabezado, no copia el payload.
      Entra: bytes: payload + CRC
        (packet_len).
      Sale: bytes: encabezado de 12
        bytes (packet_len = 12).
    format: formato_trama
    len_tag_key: '"packet_len"'
  states: {}
- name: txA_fuente
  id: blocks_vector_source_x
  parameters:
    comment: |-
      Entrega una y otra vez el mensaje del nodo A
      (lista "payload_A").
      Entra: nada (es una fuente).
      Sale: bytes del mensaje.
    repeat: 'True'
    type: byte
    vector: payload_A
  states: {}
- name: txA_modulador
  id: digital_constellation_modulator
  parameters:
    comment: |-
      Modulador 4-QAM: toma los bytes de a 2 bits,
      aplica la codificación diferencial (la
      información va en el cambio de fase entre
      símbolos) y forma cada pulso con un filtro RRC
      (roll-off 0,35).
      Entra: bytes (8 bits cada uno).
      Sale: complejos (I + jQ), 4 muestras por
        símbolo (mientras tiene el turno).
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: txA_trama
  id: blocks_tagged_stream_mux
  parameters:
    comment: |-
      Pone el encabezado delante del
      payload: arma la trama
      completa.
      Entra: in0 = encabezado (12
        bytes), in1 = payload + CRC
        (L_A + 4 bytes).
      Sale: bytes: trama de L_A + 16
        bytes (packet_len).
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: txA_vs
  id: virtual_sink
  parameters:
    comment: |-
      Conexión sin cable: la señal del nodo A sigue
      en los Virtual Source "tx_A" (canal compartido
      y gráficos).
      Entra: complejos.
      Sale: nada a la vista.
    stream_id: tx_A
  states: {}
- name: txB_a_paquetes
  id: blocks_stream_to_tagged_stream
  parameters:
    comment: |-
      Corta el flujo en grupos de L_B
      bytes (uno por trama) y marca el
      comienzo de cada grupo con la
      etiqueta packet_len. Así los bloques
      siguientes saben dónde empieza y
      termina cada trama.
      Entra: bytes sin marcas.
      Sale: los mismos bytes, en grupos de
        L_B marcados con packet_len.
    len_tag_key: '"packet_len"'
    packet_len: L_B
    type: byte
  states: {}
- name: txB_crc
  id: digital_crc32_bb
  parameters:
    check: 'False'
    comment: |-
      Calcula el CRC-32 de cada payload y se lo
      agrega al final (4 bytes). El receptor lo
      vuelve a calcular para descartar las tramas
      con errores.
      Entra: bytes: payload de L_B bytes
        (packet_len).
      Sale: bytes: payload + CRC = L_B + 4 bytes.
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: txB_encabezado
  id: digital_protocol_formatter_bb
  parameters:
    comment: |-
      Arma el encabezado de cada trama
      con el formato "formato_trama":
      preámbulo de 64 bits + longitud (2
      veces). Solo produce el
      encabezado, no copia el payload.
      Entra: bytes: payload + CRC
        (packet_len).
      Sale: bytes: encabezado de 12
        bytes (packet_len = 12).
    format: formato_trama
    len_tag_key: '"packet_len"'
  states: {}
- name: txB_fuente
  id: blocks_vector_source_x
  parameters:
    comment: |-
      Entrega una y otra vez el mensaje del nodo B
      (lista "payload_B").
      Entra: nada (es una fuente).
      Sale: bytes del mensaje.
    repeat: 'True'
    type: byte
    vector: payload_B
  states: {}
- name: txB_modulador
  id: digital_constellation_modulator
  parameters:
    comment: |-
      Modulador 4-QAM: toma los bytes de a 2 bits,
      aplica la codificación diferencial (la
      información va en el cambio de fase entre
      símbolos) y forma cada pulso con un filtro RRC
      (roll-off 0,35).
      Entra: bytes (8 bits cada uno).
      Sale: complejos (I + jQ), 4 muestras por
        símbolo (mientras tiene el turno).
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: txB_trama
  id: blocks_tagged_stream_mux
  parameters:
    comment: |-
      Pone el encabezado delante del
      payload: arma la trama
      completa.
      Entra: in0 = encabezado (12
        bytes), in1 = payload + CRC
        (L_B + 4 bytes).
      Sale: bytes: trama de L_B + 16
        bytes (packet_len).
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: txB_vs
  id: virtual_sink
  parameters:
    comment: |-
      Conexión sin cable: la señal del nodo B sigue
      en los Virtual Source "tx_B" (canal compartido
      y gráficos).
      Entra: complejos.
      Sale: nada a la vista.
    stream_id: tx_B
  states: {}

connections:
- [acelerador, '0', fase, '0']
- [acelerador, '0', modulo_canal, '0']
- [canal_tx_A, '0', turnos, '0']
- [canal_tx_B, '0', turnos, '2']
- [conmutador_rx, '0', osc_rxB, '0']
- [conmutador_rx, '1', guarda_1, '0']
- [conmutador_rx, '2', osc_rxA, '0']
- [conmutador_rx, '3', guarda_3, '0']
- [fase, '0', suma_ruido, '0']
- [g_txA_src, '0', g_txA, '0']
- [g_txB_src, '0', g_txB, '0']
- [modulo_canal, '0', g_turnos, '2']
- [osc_rxA, '0', rxA_vs_entrada, '0']
- [osc_rxB, '0', rxB_vs_entrada, '0']
- [ruido_awgn, '0', suma_ruido, '1']
- [rxA_a_bits, '0', rxA_detector_trama, '0']
- [rxA_a_bits, '0', rxA_marca_preambulo, '0']
- [rxA_a_bytes, '0', rxA_crc, '0']
- [rxA_alinear, '0', rxA_comparar, '0']
- [rxA_alinear, '0', rxA_rx_bit_f, '0']
- [rxA_alinear, '0', rxA_rx_bytes, '0']
- [rxA_ber_ventana, '0', rxA_submuestreo, '0']
- [rxA_cfo_esperado, '0', rxA_g_frec, '1']
- [rxA_comparar, '0', rxA_errores, '0']
- [rxA_costas, '0', rxA_decisor, '0']
- [rxA_costas, '0', rxA_g_const, '1']
- [rxA_costas, '1', rxA_frec_hz, '0']
- [rxA_crc, '0', rxA_una_de_cien, '0']
- [rxA_dec_diferencial, '0', rxA_mapa_gray, '0']
- [rxA_decisor, '0', rxA_dec_diferencial, '0']
- [rxA_detector_trama, '0', rxA_a_bytes, '0']
- [rxA_detector_trama, '0', rxA_payload_f, '0']
- [rxA_entrada, '0', rxA_filtro_adaptado, '0']
- [rxA_errores, '0', rxA_ber_ventana, '0']
- [rxA_errores, '0', rxA_g_bits, '2']
- [rxA_filtro_adaptado, '0', rxA_ojo_interp, '0']
- [rxA_filtro_adaptado, '0', rxA_sinc_simbolo, '0']
- [rxA_frec_hz, '0', rxA_g_frec, '0']
- [rxA_log_ber, '0', rxA_g_ber, '0']
- [rxA_log_teo, '0', rxA_g_ber, '1']
- [rxA_mapa_gray, '0', rxA_a_bits, '0']
- [rxA_marca_preambulo, '0', rxA_alinear, '0']
- [rxA_medidor_ber, '0', rxA_sonda_ber, '0']
- [rxA_ojo_interp, '0', rxA_ojo_re, '0']
- [rxA_ojo_re, '0', rxA_g_ojo, '0']
- [rxA_payload_f, '0', rxA_g_payload, '0']
- [rxA_ref_a_paquetes, '0', rxA_ref_crc, '0']
- [rxA_ref_bit_f, '0', rxA_ref_desplazar, '0']
- [rxA_ref_bits, '0', rxA_ref_saltar_preambulo, '0']
- [rxA_ref_bytes, '0', rxA_medidor_ber, '1']
- [rxA_ref_crc, '0', rxA_ref_encabezado, '0']
- [rxA_ref_crc, '0', rxA_ref_trama, '1']
- [rxA_ref_desplazar, '0', rxA_g_bits, '1']
- [rxA_ref_encabezado, '0', rxA_ref_trama, '0']
- [rxA_ref_fuente, '0', rxA_ref_a_paquetes, '0']
- [rxA_ref_saltar_preambulo, '0', rxA_comparar, '1']
- [rxA_ref_saltar_preambulo, '0', rxA_ref_bit_f, '0']
- [rxA_ref_saltar_preambulo, '0', rxA_ref_bytes, '0']
- [rxA_ref_trama, '0', rxA_ref_bits, '0']
- [rxA_rx_bit_f, '0', rxA_g_bits, '0']
- [rxA_rx_bytes, '0', rxA_medidor_ber, '0']
- [rxA_sinc_simbolo, '0', rxA_costas, '0']
- [rxA_sinc_simbolo, '0', rxA_g_const, '0']
- [rxA_sinc_simbolo, '1', rxA_sinc_null_1, '0']
- [rxA_sinc_simbolo, '2', rxA_sinc_null_2, '0']
- [rxA_sinc_simbolo, '3', rxA_sinc_null_3, '0']
- [rxA_submuestreo, '0', rxA_log_ber, '0']
- [rxA_una_de_cien, '0', rxA_archivo, '0']
- [rxB_a_bits, '0', rxB_detector_trama, '0']
- [rxB_a_bits, '0', rxB_marca_preambulo, '0']
- [rxB_a_bytes, '0', rxB_crc, '0']
- [rxB_alinear, '0', rxB_comparar, '0']
- [rxB_alinear, '0', rxB_rx_bit_f, '0']
- [rxB_alinear, '0', rxB_rx_bytes, '0']
- [rxB_ber_ventana, '0', rxB_submuestreo, '0']
- [rxB_cfo_esperado, '0', rxB_g_frec, '1']
- [rxB_comparar, '0', rxB_errores, '0']
- [rxB_costas, '0', rxB_decisor, '0']
- [rxB_costas, '0', rxB_g_const, '1']
- [rxB_costas, '1', rxB_frec_hz, '0']
- [rxB_crc, '0', rxB_una_de_cien, '0']
- [rxB_dec_diferencial, '0', rxB_mapa_gray, '0']
- [rxB_decisor, '0', rxB_dec_diferencial, '0']
- [rxB_detector_trama, '0', rxB_a_bytes, '0']
- [rxB_detector_trama, '0', rxB_payload_f, '0']
- [rxB_entrada, '0', rxB_filtro_adaptado, '0']
- [rxB_errores, '0', rxB_ber_ventana, '0']
- [rxB_errores, '0', rxB_g_bits, '2']
- [rxB_filtro_adaptado, '0', rxB_ojo_interp, '0']
- [rxB_filtro_adaptado, '0', rxB_sinc_simbolo, '0']
- [rxB_frec_hz, '0', rxB_g_frec, '0']
- [rxB_log_ber, '0', rxB_g_ber, '0']
- [rxB_log_teo, '0', rxB_g_ber, '1']
- [rxB_mapa_gray, '0', rxB_a_bits, '0']
- [rxB_marca_preambulo, '0', rxB_alinear, '0']
- [rxB_medidor_ber, '0', rxB_sonda_ber, '0']
- [rxB_ojo_interp, '0', rxB_ojo_re, '0']
- [rxB_ojo_re, '0', rxB_g_ojo, '0']
- [rxB_payload_f, '0', rxB_g_payload, '0']
- [rxB_ref_a_paquetes, '0', rxB_ref_crc, '0']
- [rxB_ref_bit_f, '0', rxB_ref_desplazar, '0']
- [rxB_ref_bits, '0', rxB_ref_saltar_preambulo, '0']
- [rxB_ref_bytes, '0', rxB_medidor_ber, '1']
- [rxB_ref_crc, '0', rxB_ref_encabezado, '0']
- [rxB_ref_crc, '0', rxB_ref_trama, '1']
- [rxB_ref_desplazar, '0', rxB_g_bits, '1']
- [rxB_ref_encabezado, '0', rxB_ref_trama, '0']
- [rxB_ref_fuente, '0', rxB_ref_a_paquetes, '0']
- [rxB_ref_saltar_preambulo, '0', rxB_comparar, '1']
- [rxB_ref_saltar_preambulo, '0', rxB_ref_bit_f, '0']
- [rxB_ref_saltar_preambulo, '0', rxB_ref_bytes, '0']
- [rxB_ref_trama, '0', rxB_ref_bits, '0']
- [rxB_rx_bit_f, '0', rxB_g_bits, '0']
- [rxB_rx_bytes, '0', rxB_medidor_ber, '0']
- [rxB_sinc_simbolo, '0', rxB_costas, '0']
- [rxB_sinc_simbolo, '0', rxB_g_const, '0']
- [rxB_sinc_simbolo, '1', rxB_sinc_null_1, '0']
- [rxB_sinc_simbolo, '2', rxB_sinc_null_2, '0']
- [rxB_sinc_simbolo, '3', rxB_sinc_null_3, '0']
- [rxB_submuestreo, '0', rxB_log_ber, '0']
- [rxB_una_de_cien, '0', rxB_archivo, '0']
- [silencio_1, '0', turnos, '1']
- [silencio_3, '0', turnos, '3']
- [suma_ruido, '0', conmutador_rx, '0']
- [suma_ruido, '0', g_canal_const, '0']
- [suma_ruido, '0', g_canal_esp, '0']
- [turno_A, '0', g_turnos, '0']
- [turno_B, '0', g_turnos, '1']
- [turnos, '0', acelerador, '0']
- [txA_a_paquetes, '0', txA_crc, '0']
- [txA_crc, '0', txA_encabezado, '0']
- [txA_crc, '0', txA_trama, '1']
- [txA_encabezado, '0', txA_trama, '0']
- [txA_fuente, '0', txA_a_paquetes, '0']
- [txA_modulador, '0', txA_vs, '0']
- [txA_trama, '0', txA_modulador, '0']
- [txB_a_paquetes, '0', txB_crc, '0']
- [txB_crc, '0', txB_encabezado, '0']
- [txB_crc, '0', txB_trama, '1']
- [txB_encabezado, '0', txB_trama, '0']
- [txB_fuente, '0', txB_a_paquetes, '0']
- [txB_modulador, '0', txB_vs, '0']
- [txB_trama, '0', txB_modulador, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
