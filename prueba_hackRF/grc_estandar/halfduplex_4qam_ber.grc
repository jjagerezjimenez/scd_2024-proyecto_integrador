options:
  parameters:
    author: Juan Gerez
    comment: |-
      Opciones del flowgraph: SIN interfaz (No GUI),
      para medir. Lo compila y lo corre
      run_ber_sweep.py con distintos parámetros
      (Eb/N0, fase, CFO, ...); termina solo cuando
      el Head llega a "muestras".
    description: El mismo enlace half-duplex de halfduplex_4qam.grc, sin gráficos, para medir BER por línea de comandos
    generate_options: no_gui
    id: halfduplex_4qam_ber
    output_language: python
    run_options: run
    title: Medición de BER del enlace half-duplex 4-QAM (sin interfaz)
  states: {}

blocks:
- name: L_A
  id: variable
  parameters:
    comment: |-
      Bytes de payload de cada trama del nodo A
      (largo de su mensaje).
    value: len(payload_A)
  states: {}
- name: L_B
  id: variable
  parameters:
    comment: Bytes de payload de cada trama del nodo B.
    value: len(payload_B)
  states: {}
- name: excess_bw
  id: variable
  parameters:
    comment: |-
      Roll-off del filtro RRC (0,35): cuánto más
      ancho que el mínimo es el espectro. La señal
      ocupa 125 k × 1,35 ≈ 170 kHz.
    value: '0.35'
  states: {}
- name: formato_trama
  id: variable_header_format_default
  parameters:
    access_code: '0'
    bps: '1'
    comment: |-
      Formato del encabezado de cada trama:
      preámbulo de 64 bits (Access Code 0 = el
      preámbulo estándar de GNU Radio) + longitud
      del payload en 16 bits, escrita 2 veces. Lo
      usan los Protocol Formatter.
    threshold: '0'
  states: {}
- name: guarda
  id: variable
  parameters:
    comment: |-
      Muestras de silencio entre turnos (nadie
      transmite).
    value: '256'
  states: {}
- name: mensaje_A
  id: variable
  parameters:
    comment: Texto que transmite el nodo A en cada trama.
    value: '"Hola, soy el nodo A. Este mensaje viaja por el canal compartido en mi ranura de tiempo (TDD)."'
  states: {}
- name: mensaje_B
  id: variable
  parameters:
    comment: Texto que transmite el nodo B en cada trama.
    value: '"Hola, soy el nodo B. Respondo en la otra ranura: nunca transmitimos los dos al mismo tiempo!!"'
  states: {}
- name: payload_A
  id: variable
  parameters:
    comment: |-
      El mensaje del nodo A como lista de bytes
      (números de 0 a 255).
    value: list(mensaje_A.encode())
  states: {}
- name: payload_B
  id: variable
  parameters:
    comment: El mensaje del nodo B como lista de bytes.
    value: list(mensaje_B.encode())
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    comment: |-
      Constelación 4-QAM: 4 puntos (±0,707 ± j0,707)
      con código Gray (Symbol Map 0, 1, 3, 2: los
      vecinos difieren en un solo bit). La usan los
      moduladores y los decisores.
    const_points: '[-0.707-0.707j, 0.707-0.707j, +0.707+0.707j, -0.707+0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: ranura
  id: variable
  parameters:
    comment: |-
      Muestras de cada turno de transmisión (2048 =
      512 símbolos; tiene que ser múltiplo de sps).
    value: '2048'
  states: {}
- name: ruido
  id: variable
  parameters:
    comment: |-
      Amplitud del ruido que agrega el canal,
      calculada para que haya el Eb/N0 elegido: la
      señal tiene potencia 1 y 4 muestras por
      símbolo, y Es/N0 = 2 Eb/N0 (2 bits por
      símbolo).
    value: math.sqrt(sps / (2 * 10**(ebn0_db / 10)))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      Muestreo: 500 000 muestras por segundo. Con 4
      muestras por símbolo son 125 000 símbolos/s =
      250 kbit/s mientras un nodo transmite.
    value: '500000'
  states: {}
- name: sps
  id: variable
  parameters:
    comment: Muestras por símbolo (4).
    value: '4'
  states: {}
- name: umbral
  id: variable
  parameters:
    comment: |-
      Cuántos bits del preámbulo (de 64) pueden
      llegar mal y aun así se acepta la trama.
    value: '12'
  states: {}
- name: canal_tx_A
  id: virtual_source
  parameters:
    comment: |-
      Toma sin cable la señal
      del nodo A (Virtual Sink
      "tx_A").
      Entra: nada a la vista.
      Sale: complejos.
    stream_id: tx_A
  states: {}
- name: canal_tx_B
  id: virtual_source
  parameters:
    comment: |-
      Toma sin cable la señal
      del nodo B (Virtual Sink
      "tx_B").
      Entra: nada a la vista.
      Sale: complejos.
    stream_id: tx_B
  states: {}
- name: cfo_hz
  id: parameter
  parameters:
    comment: |-
      Parámetro: diferencia de frecuencia entre los
      osciladores de A y B, en Hz (--cfo-hz).
    label: Desvio entre osciladores A-B [Hz]
    type: eng_float
    value: '0.0'
  states: {}
- name: conmutador_rx
  id: blocks_stream_demux
  parameters:
    comment: |-
      Conmutador de recepción:
      reparte las muestras con los
      mismos turnos: la ranura de A
      va a out0 (receptor de B), la
      de B a out2 (receptor de A) y
      las guardas a out1 y out3 (se
      tiran).
      Entra: complejos.
      Sale: 4 salidas de complejos.
    lengths: '[ranura, guarda, ranura, guarda]'
    num_outputs: '4'
    type: complex
  states: {}
- name: costas_bw
  id: parameter
  parameters:
    comment: |-
      Parámetro: ancho de banda de los lazos de
      Costas (0 = no corrigen la fase)
      (--costas-bw).
    label: BW del lazo de Costas (0 = sin corregir fase)
    type: eng_float
    value: '0.005'
  states: {}
- name: descartar
  id: parameter
  parameters:
    comment: |-
      Parámetro: bits que no se cuentan al comienzo,
      mientras se enganchan los lazos (--descartar).
    label: Bits descartados al inicio (enganche de los lazos)
    type: intx
    value: '100000'
  states: {}
- name: ebn0_db
  id: parameter
  parameters:
    comment: |-
      Parámetro: Eb/N0 del canal en dB.
      run_ber_sweep.py lo cambia en cada medición
      (--ebn0-db).
    label: Eb/N0 [dB]
    type: eng_float
    value: '6.0'
  states: {}
- name: fase
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      Gira la constelación la
      fase elegida (multiplica
      por e^(j·fase)).
      Entra: complejos.
      Sale: complejos girados.
    const: cmath.exp(1j * math.radians(fase_deg))
    type: complex
  states: {}
- name: fase_deg
  id: parameter
  parameters:
    comment: |-
      Parámetro: fase que gira el canal, en grados
      (--fase-deg).
    label: Fase del canal [grados]
    type: eng_float
    value: '0.0'
  states: {}
- name: guarda_1
  id: blocks_null_sink
  parameters:
    comment: |-
      Tira la guarda que
      sigue al turno de A.
      Entra: complejos.
      Sale: nada.
    type: complex
  states: {}
- name: guarda_3
  id: blocks_null_sink
  parameters:
    comment: |-
      Tira la guarda que
      sigue al turno de B.
      Entra: complejos.
      Sale: nada.
    type: complex
  states: {}
- name: imports
  id: import
  parameters:
    comment: |-
      Módulos de Python que usan las variables y los
      bloques: math y cmath (cuentas con números
      complejos).
    imports: import math, cmath
  states: {}
- name: limite
  id: blocks_head
  parameters:
    comment: |-
      Deja pasar solo "muestras"
      muestras y después termina
      el flujo: así el flowgraph
      termina solo y
      run_ber_sweep.py lee los
      resultados.
      Entra: complejos.
      Sale: los mismos complejos,
        hasta el límite.
    num_items: muestras
    type: complex
  states: {}
- name: muestras
  id: parameter
  parameters:
    comment: |-
      Parámetro: cuántas muestras del canal
      compartido se simulan antes de terminar
      (--muestras).
    label: Muestras del canal compartido
    type: intx
    value: '4000000'
  states: {}
- name: nota_tdd
  id: note
  parameters:
    comment: |-
      CANAL COMPARTIDO (TDD)
      Stream Mux = turnos [A | guarda | B | guarda];
      Head limita la cantidad de muestras y hace que
      el flowgraph termine solo; Stream Demux =
      conmutador de recepción.
    note: 'CANAL COMPARTIDO (TDD): Stream Mux = turnos [A | guarda | B | guarda]; Head limita la cantidad de muestras y hace que el flowgraph termine solo; Stream Demux = conmutador de recepción.'
  states: {}
- name: nota_tx
  id: note
  parameters:
    comment: |-
      TRANSMISORES
      cada nodo arma sus tramas (mensaje -> CRC-32
      -> preámbulo de 64 bits + longitud ×2) y las
      modula en 4-QAM diferencial con filtro RRC.
    note: TRANSMISORES de los nodos A y B (igual que halfduplex_4qam.grc)
  states: {}
- name: osc_rxA
  id: blocks_rotator_cc
  parameters:
    comment: |-
      Oscilador del receptor de A: le agrega a lo
      que transmitió B el desvío -CFO (signo opuesto
      al que ve B).
      Entra: complejos (ranuras de B).
      Sale: complejos con -CFO.
    phase_inc: '-2 * math.pi * cfo_hz / samp_rate'
  states: {}
- name: osc_rxB
  id: blocks_rotator_cc
  parameters:
    comment: |-
      Oscilador del receptor de B: le agrega a lo
      que transmitió A el desvío de frecuencia +CFO
      (la diferencia entre los osciladores de los
      dos nodos).
      Entra: complejos (ranuras de A).
      Sale: complejos con +CFO.
    phase_inc: 2 * math.pi * cfo_hz / samp_rate
  states: {}
- name: ruido_awgn
  id: analog_noise_source_x
  parameters:
    amp: ruido
    comment: |-
      Genera ruido blanco gaussiano complejo, con la
      amplitud "ruido" (según el Eb/N0 elegido).
      Entra: nada (es una fuente).
      Sale: complejos (ruido).
    noise_type: analog.GR_GAUSSIAN
    seed: semilla
    type: complex
  states: {}
- name: rxA_a_bits
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: |-
      Separa cada número en sus 2 bits (primero el
      más significativo).
      Entra: bytes con 2 bits útiles (0 a 3).
      Sale: bits sueltos (1 bit por byte: 0 o 1).
    k: '2'
  states: {}
- name: rxA_a_bytes
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    comment: |-
      Junta los bits de a 8 para volver a formar
      bytes, respetando dónde empieza cada trama
      (packet_len).
      Entra: bits sueltos (1 por byte).
      Sale: bytes: L_B + 4 por trama (packet_len).
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
    minoutbuf: '70000'
  states: {}
- name: rxA_a_pdu
  id: pdu_tagged_stream_to_pdu
  parameters:
    comment: |-
      Convierte cada payload correcto (marcado con
      packet_len) en un mensaje (PDU).
      Entra: bytes con packet_len.
      Sale: mensajes (PDU).
    tag: '"packet_len"'
    type: byte
  states: {}
- name: rxA_alinear
  id: blocks_tagged_stream_align
  parameters:
    comment: |-
      Descarta los bits que llegan antes
      de la primera etiqueta
      inicio_trama: así lo recibido
      arranca justo después de un
      preámbulo, alineado con la copia
      del transmisor.
      Entra: bits con etiquetas.
      Sale: bits alineados.
    lengthtagname: '"inicio_trama"'
    type: byte
  states: {}
- name: rxA_costas
  id: digital_costas_loop_cc
  parameters:
    comment: |-
      Lazo de Costas de orden 4: corrige
      la fase y el desvío de frecuencia
      del canal, para que la
      constelación quede quieta en los 4
      puntos.
      Entra: complejos, 1 muestra por
        símbolo.
      Sale: out0 = símbolos corregidos
        (complejos); out1 a out3 =
        frecuencia, fase y error (no se
        usan).
    order: '4'
    w: costas_bw
  states: {}
- name: rxA_crc
  id: digital_crc32_bb
  parameters:
    check: 'True'
    comment: |-
      Vuelve a calcular el CRC-32 de
      cada trama: si coincide, la deja
      pasar sin los 4 bytes del CRC;
      si no, la descarta (tenía
      errores).
      Entra: bytes: payload + CRC (L_B
        + 4).
      Sale: bytes: payloads correctos
        (L_B bytes cada uno).
    lengthtagname: '"packet_len"'
    minoutbuf: '70000'
    packed: 'True'
  states: {}
- name: rxA_dec_diferencial
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: |-
      Decodificación diferencial: resta el símbolo
      anterior (módulo 4), o sea, mide el cambio de
      fase. Por eso no importa si Costas quedó
      girado 90°, 180° o 270°.
      Entra: símbolos 0 a 3 (bytes).
      Sale: símbolos 0 a 3 (el cambio de fase).
    modulus: '4'
  states: {}
- name: rxA_decisor
  id: digital_constellation_decoder_cb
  parameters:
    comment: |-
      Decide a cuál de los 4 puntos de la
      constelación está más cerca cada símbolo y
      entrega su número.
      Entra: complejos, 1 por símbolo.
      Sale: bytes con valores 0 a 3 (un símbolo cada
        uno).
    constellation: qpsk
  states: {}
- name: rxA_detector_trama
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: digital.packet_utils.default_access_code
    comment: |-
      Busca en los bits el preámbulo de 64
      bits (acepta hasta "umbral" bits mal),
      lee la longitud (2 copias que tienen que
      coincidir) y entrega solo el payload +
      CRC de cada trama, marcado con
      packet_len.
      Entra: bits sueltos (1 por byte).
      Sale: bits sueltos: 8 × (L_B + 4) por
        trama.
      (En Advanced, Min Output Buffer =
      600000: lugar para la trama más larga,
      así una longitud dañada no traba el
      flujo.)
    minoutbuf: '600000'
    tagname: '"packet_len"'
    threshold: umbral
    type: byte
  states: {}
- name: rxA_entrada
  id: virtual_source
  parameters:
    comment: |-
      Toma sin cable lo que le
      llega al nodo A (Virtual
      Sink "entrada_rx_A"): solo
      las ranuras en que
      transmite B, una tras
      otra.
      Entra: nada a la vista.
      Sale: complejos.
    stream_id: entrada_rx_A
  states: {}
- name: rxA_filtro_adaptado
  id: filter_fft_rrc_filter
  parameters:
    alpha: excess_bw
    comment: |-
      Filtro adaptado RRC (igual al del
      transmisor): junto con el del TX
      da un pulso sin interferencia
      entre símbolos y deja afuera la
      mayor parte del ruido.
      Entra: complejos, 4 muestras por
        símbolo.
      Sale: complejos filtrados, 4
        muestras por símbolo.
    decim: '1'
    gain: '1'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: ccc
  states: {}
- name: rxA_mapa_gray
  id: digital_map_bb
  parameters:
    comment: |-
      Deshace el código Gray: cambia cada símbolo
      por los 2 bits que mandó el transmisor (0->0,
      1->1, 2->3, 3->2).
      Entra: símbolos 0 a 3 (bytes).
      Sale: números 0 a 3 = 2 bits de datos (bytes).
    map: '[0, 1, 3, 2]'
  states: {}
- name: rxA_marca_preambulo
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: digital.packet_utils.default_access_code
    comment: |-
      Busca el preámbulo en los bits y pone una
      etiqueta "inicio_trama" donde termina. No
      quita nada.
      Entra: bits sueltos (1 por byte).
      Sale: los mismos bits, con etiquetas
        inicio_trama.
    tagname: '"inicio_trama"'
    threshold: umbral
    type: byte
  states: {}
- name: rxA_medidor_ber
  id: fec_ber_bf
  parameters:
    comment: |-
      Cuenta los bits
      distintos entre sus dos
      entradas desde el
      comienzo y entrega el
      log10 del BER acumulado
      (con 0 errores da
      -infinito).
      Entra: in0 = bytes
        recibidos, in1 = bytes
        transmitidos.
      Sale: reales: log10(BER
        acumulado).
    test_mode: 'False'
  states: {}
- name: rxA_mensajes
  id: blocks_message_debug
  parameters:
    comment: |-
      Guarda los mensajes recibidos (entrada
      "store"): run_ber_sweep.py los cuenta al final
      para saber cuántas tramas pasaron el CRC.
      Entra: mensajes (PDU).
      Sale: nada.
  states: {}
- name: rxA_nota
  id: note
  parameters:
    comment: |-
      RECEPTOR DEL NODO A (recibe lo que transmite
      B)
      resultados en rxA_medidor_ber (errores y BER)
      y rxA_mensajes (tramas con CRC correcto)
    note: 'RECEPTOR DEL NODO A (recibe lo que transmite B): resultados en rxA_medidor_ber (errores y BER) y rxA_mensajes (tramas con CRC correcto)'
  states: {}
- name: rxA_ref_a_paquetes
  id: blocks_stream_to_tagged_stream
  parameters:
    comment: |-
      Copia del transmisor: corta en
      grupos de L_B bytes marcados con
      packet_len.
      Entra: bytes.
      Sale: bytes en grupos marcados.
    len_tag_key: '"packet_len"'
    packet_len: L_B
    type: byte
  states: {}
- name: rxA_ref_bits
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: |-
      Separa cada byte de las tramas de referencia
      en sus 8 bits (primero el más significativo).
      Entra: bytes.
      Sale: bits sueltos (1 por byte).
    k: '8'
  states: {}
- name: rxA_ref_bytes
  id: blocks_repack_bits_bb
  parameters:
    comment: |-
      Junta los bits transmitidos de a 8, como los
      recibidos.
      Entra: bits sueltos.
      Sale: bytes.
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: rxA_ref_crc
  id: digital_crc32_bb
  parameters:
    check: 'False'
    comment: |-
      Copia del transmisor: agrega el CRC-32 de cada
      payload.
      Entra: bytes: payload (packet_len).
      Sale: bytes: payload + CRC.
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: rxA_ref_descartar
  id: blocks_skiphead
  parameters:
    comment: |-
      Saltea la misma cantidad de bits transmitidos,
      para que las dos entradas del medidor sigan
      alineadas.
      Entra: bits sueltos.
      Sale: los mismos bits, sin los primeros.
    num_items: descartar
    type: byte
  states: {}
- name: rxA_ref_encabezado
  id: digital_protocol_formatter_bb
  parameters:
    comment: |-
      Copia del transmisor: arma el
      encabezado (preámbulo + longitud
      ×2).
      Entra: bytes: payload + CRC.
      Sale: bytes: encabezado (12
        bytes).
    format: formato_trama
    len_tag_key: '"packet_len"'
  states: {}
- name: rxA_ref_fuente
  id: blocks_vector_source_x
  parameters:
    comment: |-
      Copia del transmisor, para saber qué bits se
      mandaron: entrega una y otra vez el mensaje
      del nodo B (lista "payload_B").
      Entra: nada (es una fuente).
      Sale: bytes.
    repeat: 'True'
    type: byte
    vector: payload_B
  states: {}
- name: rxA_ref_saltar_preambulo
  id: blocks_skiphead
  parameters:
    comment: |-
      Saltea los primeros 64 bits (el
      primer preámbulo), para arrancar
      en el mismo lugar que lo recibido
      después de "alinear".
      Entra: bits sueltos.
      Sale: los mismos bits, sin los 64
        primeros.
    num_items: '64'
    type: byte
  states: {}
- name: rxA_ref_trama
  id: blocks_tagged_stream_mux
  parameters:
    comment: |-
      Copia del transmisor: pone el
      encabezado delante del
      payload.
      Entra: in0 = encabezado, in1 =
        payload + CRC.
      Sale: bytes: tramas completas.
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: rxA_rx_bytes
  id: blocks_repack_bits_bb
  parameters:
    comment: |-
      Junta los bits recibidos de a 8, sin mirar
      etiquetas: el medidor de BER compara bytes.
      Entra: bits sueltos.
      Sale: bytes.
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: rxA_rx_descartar
  id: blocks_skiphead
  parameters:
    comment: |-
      No cuenta los primeros "descartar" bits
      recibidos (mientras se enganchan los lazos).
      Entra: bits sueltos.
      Sale: los mismos bits, sin los primeros.
    num_items: descartar
    type: byte
  states: {}
- name: rxA_sinc_null_1
  id: blocks_null_sink
  parameters:
    comment: |-
      Descarta el error del
      sincronismo de símbolo (no se
      usa).
      Entra: reales.
      Sale: nada.
    type: float
  states: {}
- name: rxA_sinc_null_2
  id: blocks_null_sink
  parameters:
    comment: |-
      Descarta el período
      instantáneo del sincronismo de
      símbolo (no se usa).
      Entra: reales.
      Sale: nada.
    type: float
  states: {}
- name: rxA_sinc_null_3
  id: blocks_null_sink
  parameters:
    comment: |-
      Descarta el período promedio
      del sincronismo de símbolo (no
      se usa).
      Entra: reales.
      Sale: nada.
    type: float
  states: {}
- name: rxA_sinc_simbolo
  id: digital_symbol_sync_xx
  parameters:
    comment: |-
      Sincronismo de símbolo: encuentra el mejor
      instante para muestrear cada símbolo (el
      centro del ojo) y entrega una muestra por
      símbolo.
      Entra: complejos, 4 muestras por símbolo.
      Sale: out0 = complejos, 1 muestra por símbolo;
        out1 = error, out2 = período instantáneo y
        out3 = período promedio del reloj (reales).
    damping: '1.0'
    loop_bw: sync_bw
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: rxA_sonda_ber
  id: blocks_probe_signal_x
  parameters:
    comment: |-
      Guarda el último valor que le llega, para que
      run_ber_sweep.py lo pueda leer.
      Entra: reales.
      Sale: nada (se lee con la función level() del
        bloque).
    type: float
  states: {}
- name: rxA_vs_entrada
  id: virtual_sink
  parameters:
    comment: |-
      Conexión sin cable: lo que le llega al nodo A
      sigue en el Virtual Source "entrada_rx_A"
      (receptor de A).
      Entra: complejos.
      Sale: nada a la vista.
    stream_id: entrada_rx_A
  states: {}
- name: rxB_a_bits
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: |-
      Separa cada número en sus 2 bits (primero el
      más significativo).
      Entra: bytes con 2 bits útiles (0 a 3).
      Sale: bits sueltos (1 bit por byte: 0 o 1).
    k: '2'
  states: {}
- name: rxB_a_bytes
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    comment: |-
      Junta los bits de a 8 para volver a formar
      bytes, respetando dónde empieza cada trama
      (packet_len).
      Entra: bits sueltos (1 por byte).
      Sale: bytes: L_A + 4 por trama (packet_len).
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
    minoutbuf: '70000'
  states: {}
- name: rxB_a_pdu
  id: pdu_tagged_stream_to_pdu
  parameters:
    comment: |-
      Convierte cada payload correcto (marcado con
      packet_len) en un mensaje (PDU).
      Entra: bytes con packet_len.
      Sale: mensajes (PDU).
    tag: '"packet_len"'
    type: byte
  states: {}
- name: rxB_alinear
  id: blocks_tagged_stream_align
  parameters:
    comment: |-
      Descarta los bits que llegan antes
      de la primera etiqueta
      inicio_trama: así lo recibido
      arranca justo después de un
      preámbulo, alineado con la copia
      del transmisor.
      Entra: bits con etiquetas.
      Sale: bits alineados.
    lengthtagname: '"inicio_trama"'
    type: byte
  states: {}
- name: rxB_costas
  id: digital_costas_loop_cc
  parameters:
    comment: |-
      Lazo de Costas de orden 4: corrige
      la fase y el desvío de frecuencia
      del canal, para que la
      constelación quede quieta en los 4
      puntos.
      Entra: complejos, 1 muestra por
        símbolo.
      Sale: out0 = símbolos corregidos
        (complejos); out1 a out3 =
        frecuencia, fase y error (no se
        usan).
    order: '4'
    w: costas_bw
  states: {}
- name: rxB_crc
  id: digital_crc32_bb
  parameters:
    check: 'True'
    comment: |-
      Vuelve a calcular el CRC-32 de
      cada trama: si coincide, la deja
      pasar sin los 4 bytes del CRC;
      si no, la descarta (tenía
      errores).
      Entra: bytes: payload + CRC (L_A
        + 4).
      Sale: bytes: payloads correctos
        (L_A bytes cada uno).
    lengthtagname: '"packet_len"'
    minoutbuf: '70000'
    packed: 'True'
  states: {}
- name: rxB_dec_diferencial
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: |-
      Decodificación diferencial: resta el símbolo
      anterior (módulo 4), o sea, mide el cambio de
      fase. Por eso no importa si Costas quedó
      girado 90°, 180° o 270°.
      Entra: símbolos 0 a 3 (bytes).
      Sale: símbolos 0 a 3 (el cambio de fase).
    modulus: '4'
  states: {}
- name: rxB_decisor
  id: digital_constellation_decoder_cb
  parameters:
    comment: |-
      Decide a cuál de los 4 puntos de la
      constelación está más cerca cada símbolo y
      entrega su número.
      Entra: complejos, 1 por símbolo.
      Sale: bytes con valores 0 a 3 (un símbolo cada
        uno).
    constellation: qpsk
  states: {}
- name: rxB_detector_trama
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: digital.packet_utils.default_access_code
    comment: |-
      Busca en los bits el preámbulo de 64
      bits (acepta hasta "umbral" bits mal),
      lee la longitud (2 copias que tienen que
      coincidir) y entrega solo el payload +
      CRC de cada trama, marcado con
      packet_len.
      Entra: bits sueltos (1 por byte).
      Sale: bits sueltos: 8 × (L_A + 4) por
        trama.
      (En Advanced, Min Output Buffer =
      600000: lugar para la trama más larga,
      así una longitud dañada no traba el
      flujo.)
    minoutbuf: '600000'
    tagname: '"packet_len"'
    threshold: umbral
    type: byte
  states: {}
- name: rxB_entrada
  id: virtual_source
  parameters:
    comment: |-
      Toma sin cable lo que le
      llega al nodo B (Virtual
      Sink "entrada_rx_B"): solo
      las ranuras en que
      transmite A, una tras
      otra.
      Entra: nada a la vista.
      Sale: complejos.
    stream_id: entrada_rx_B
  states: {}
- name: rxB_filtro_adaptado
  id: filter_fft_rrc_filter
  parameters:
    alpha: excess_bw
    comment: |-
      Filtro adaptado RRC (igual al del
      transmisor): junto con el del TX
      da un pulso sin interferencia
      entre símbolos y deja afuera la
      mayor parte del ruido.
      Entra: complejos, 4 muestras por
        símbolo.
      Sale: complejos filtrados, 4
        muestras por símbolo.
    decim: '1'
    gain: '1'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: ccc
  states: {}
- name: rxB_mapa_gray
  id: digital_map_bb
  parameters:
    comment: |-
      Deshace el código Gray: cambia cada símbolo
      por los 2 bits que mandó el transmisor (0->0,
      1->1, 2->3, 3->2).
      Entra: símbolos 0 a 3 (bytes).
      Sale: números 0 a 3 = 2 bits de datos (bytes).
    map: '[0, 1, 3, 2]'
  states: {}
- name: rxB_marca_preambulo
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: digital.packet_utils.default_access_code
    comment: |-
      Busca el preámbulo en los bits y pone una
      etiqueta "inicio_trama" donde termina. No
      quita nada.
      Entra: bits sueltos (1 por byte).
      Sale: los mismos bits, con etiquetas
        inicio_trama.
    tagname: '"inicio_trama"'
    threshold: umbral
    type: byte
  states: {}
- name: rxB_medidor_ber
  id: fec_ber_bf
  parameters:
    comment: |-
      Cuenta los bits
      distintos entre sus dos
      entradas desde el
      comienzo y entrega el
      log10 del BER acumulado
      (con 0 errores da
      -infinito).
      Entra: in0 = bytes
        recibidos, in1 = bytes
        transmitidos.
      Sale: reales: log10(BER
        acumulado).
    test_mode: 'False'
  states: {}
- name: rxB_mensajes
  id: blocks_message_debug
  parameters:
    comment: |-
      Guarda los mensajes recibidos (entrada
      "store"): run_ber_sweep.py los cuenta al final
      para saber cuántas tramas pasaron el CRC.
      Entra: mensajes (PDU).
      Sale: nada.
  states: {}
- name: rxB_nota
  id: note
  parameters:
    comment: |-
      RECEPTOR DEL NODO B (recibe lo que transmite
      A)
      resultados en rxB_medidor_ber (errores y BER)
      y rxB_mensajes (tramas con CRC correcto)
    note: 'RECEPTOR DEL NODO B (recibe lo que transmite A): resultados en rxB_medidor_ber (errores y BER) y rxB_mensajes (tramas con CRC correcto)'
  states: {}
- name: rxB_ref_a_paquetes
  id: blocks_stream_to_tagged_stream
  parameters:
    comment: |-
      Copia del transmisor: corta en
      grupos de L_A bytes marcados con
      packet_len.
      Entra: bytes.
      Sale: bytes en grupos marcados.
    len_tag_key: '"packet_len"'
    packet_len: L_A
    type: byte
  states: {}
- name: rxB_ref_bits
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: |-
      Separa cada byte de las tramas de referencia
      en sus 8 bits (primero el más significativo).
      Entra: bytes.
      Sale: bits sueltos (1 por byte).
    k: '8'
  states: {}
- name: rxB_ref_bytes
  id: blocks_repack_bits_bb
  parameters:
    comment: |-
      Junta los bits transmitidos de a 8, como los
      recibidos.
      Entra: bits sueltos.
      Sale: bytes.
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: rxB_ref_crc
  id: digital_crc32_bb
  parameters:
    check: 'False'
    comment: |-
      Copia del transmisor: agrega el CRC-32 de cada
      payload.
      Entra: bytes: payload (packet_len).
      Sale: bytes: payload + CRC.
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: rxB_ref_descartar
  id: blocks_skiphead
  parameters:
    comment: |-
      Saltea la misma cantidad de bits transmitidos,
      para que las dos entradas del medidor sigan
      alineadas.
      Entra: bits sueltos.
      Sale: los mismos bits, sin los primeros.
    num_items: descartar
    type: byte
  states: {}
- name: rxB_ref_encabezado
  id: digital_protocol_formatter_bb
  parameters:
    comment: |-
      Copia del transmisor: arma el
      encabezado (preámbulo + longitud
      ×2).
      Entra: bytes: payload + CRC.
      Sale: bytes: encabezado (12
        bytes).
    format: formato_trama
    len_tag_key: '"packet_len"'
  states: {}
- name: rxB_ref_fuente
  id: blocks_vector_source_x
  parameters:
    comment: |-
      Copia del transmisor, para saber qué bits se
      mandaron: entrega una y otra vez el mensaje
      del nodo A (lista "payload_A").
      Entra: nada (es una fuente).
      Sale: bytes.
    repeat: 'True'
    type: byte
    vector: payload_A
  states: {}
- name: rxB_ref_saltar_preambulo
  id: blocks_skiphead
  parameters:
    comment: |-
      Saltea los primeros 64 bits (el
      primer preámbulo), para arrancar
      en el mismo lugar que lo recibido
      después de "alinear".
      Entra: bits sueltos.
      Sale: los mismos bits, sin los 64
        primeros.
    num_items: '64'
    type: byte
  states: {}
- name: rxB_ref_trama
  id: blocks_tagged_stream_mux
  parameters:
    comment: |-
      Copia del transmisor: pone el
      encabezado delante del
      payload.
      Entra: in0 = encabezado, in1 =
        payload + CRC.
      Sale: bytes: tramas completas.
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: rxB_rx_bytes
  id: blocks_repack_bits_bb
  parameters:
    comment: |-
      Junta los bits recibidos de a 8, sin mirar
      etiquetas: el medidor de BER compara bytes.
      Entra: bits sueltos.
      Sale: bytes.
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: rxB_rx_descartar
  id: blocks_skiphead
  parameters:
    comment: |-
      No cuenta los primeros "descartar" bits
      recibidos (mientras se enganchan los lazos).
      Entra: bits sueltos.
      Sale: los mismos bits, sin los primeros.
    num_items: descartar
    type: byte
  states: {}
- name: rxB_sinc_null_1
  id: blocks_null_sink
  parameters:
    comment: |-
      Descarta el error del
      sincronismo de símbolo (no se
      usa).
      Entra: reales.
      Sale: nada.
    type: float
  states: {}
- name: rxB_sinc_null_2
  id: blocks_null_sink
  parameters:
    comment: |-
      Descarta el período
      instantáneo del sincronismo de
      símbolo (no se usa).
      Entra: reales.
      Sale: nada.
    type: float
  states: {}
- name: rxB_sinc_null_3
  id: blocks_null_sink
  parameters:
    comment: |-
      Descarta el período promedio
      del sincronismo de símbolo (no
      se usa).
      Entra: reales.
      Sale: nada.
    type: float
  states: {}
- name: rxB_sinc_simbolo
  id: digital_symbol_sync_xx
  parameters:
    comment: |-
      Sincronismo de símbolo: encuentra el mejor
      instante para muestrear cada símbolo (el
      centro del ojo) y entrega una muestra por
      símbolo.
      Entra: complejos, 4 muestras por símbolo.
      Sale: out0 = complejos, 1 muestra por símbolo;
        out1 = error, out2 = período instantáneo y
        out3 = período promedio del reloj (reales).
    damping: '1.0'
    loop_bw: sync_bw
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: rxB_sonda_ber
  id: blocks_probe_signal_x
  parameters:
    comment: |-
      Guarda el último valor que le llega, para que
      run_ber_sweep.py lo pueda leer.
      Entra: reales.
      Sale: nada (se lee con la función level() del
        bloque).
    type: float
  states: {}
- name: rxB_vs_entrada
  id: virtual_sink
  parameters:
    comment: |-
      Conexión sin cable: lo que le llega al nodo B
      sigue en el Virtual Source "entrada_rx_B"
      (receptor de B).
      Entra: complejos.
      Sale: nada a la vista.
    stream_id: entrada_rx_B
  states: {}
- name: semilla
  id: parameter
  parameters:
    comment: |-
      Parámetro: semilla del ruido: con la misma
      semilla sale el mismo resultado (--semilla).
    label: Semilla del ruido
    type: intx
    value: '1'
  states: {}
- name: silencio_1
  id: blocks_null_source
  parameters:
    comment: |-
      Entrega ceros: el
      silencio de la guarda
      después del turno de A.
      Entra: nada (es una
        fuente).
      Sale: complejos (0).
    type: complex
  states: {}
- name: silencio_3
  id: blocks_null_source
  parameters:
    comment: |-
      Entrega ceros: el
      silencio de la guarda
      después del turno de B.
      Entra: nada (es una
        fuente).
      Sale: complejos (0).
    type: complex
  states: {}
- name: suma_ruido
  id: blocks_add_xx
  parameters:
    comment: |-
      Suma la señal y el
      ruido: es lo que hay
      en el canal
      compartido.
      Entra: in0 = señal,
        in1 = ruido
        (complejos).
      Sale: complejos.
    type: complex
  states: {}
- name: sync_bw
  id: parameter
  parameters:
    comment: |-
      Parámetro: ancho de banda de los lazos del
      sincronismo de símbolo (--sync-bw).
    label: BW del sincronismo de simbolo
    type: eng_float
    value: '0.01'
  states: {}
- name: turnos
  id: blocks_stream_mux
  parameters:
    comment: |-
      Arma los turnos: toma "ranura"
      muestras de A, "guarda" de
      silencio, "ranura" de B y "guarda"
      de silencio, y repite. Cuenta
      muestras: no mira etiquetas.
      Entra: in0 = A, in1 = silencio,
        in2 = B, in3 = silencio
        (complejos).
      Sale: complejos: [A | guarda | B |
        guarda] ...
    lengths: '[ranura, guarda, ranura, guarda]'
    num_inputs: '4'
    type: complex
  states: {}
- name: txA_a_paquetes
  id: blocks_stream_to_tagged_stream
  parameters:
    comment: |-
      Corta el flujo en grupos de L_A
      bytes (uno por trama) y marca el
      comienzo de cada grupo con la
      etiqueta packet_len. Así los bloques
      siguientes saben dónde empieza y
      termina cada trama.
      Entra: bytes sin marcas.
      Sale: los mismos bytes, en grupos de
        L_A marcados con packet_len.
    len_tag_key: '"packet_len"'
    packet_len: L_A
    type: byte
  states: {}
- name: txA_crc
  id: digital_crc32_bb
  parameters:
    check: 'False'
    comment: |-
      Calcula el CRC-32 de cada payload y se lo
      agrega al final (4 bytes). El receptor lo
      vuelve a calcular para descartar las tramas
      con errores.
      Entra: bytes: payload de L_A bytes
        (packet_len).
      Sale: bytes: payload + CRC = L_A + 4 bytes.
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: txA_encabezado
  id: digital_protocol_formatter_bb
  parameters:
    comment: |-
      Arma el encabezado de cada trama
      con el formato "formato_trama":
      preámbulo de 64 bits + longitud (2
      veces). Solo produce el
      encabezado, no copia el payload.
      Entra: bytes: payload + CRC
        (packet_len).
      Sale: bytes: encabezado de 12
        bytes (packet_len = 12).
    format: formato_trama
    len_tag_key: '"packet_len"'
  states: {}
- name: txA_fuente
  id: blocks_vector_source_x
  parameters:
    comment: |-
      Entrega una y otra vez el mensaje del nodo A
      (lista "payload_A").
      Entra: nada (es una fuente).
      Sale: bytes del mensaje.
    repeat: 'True'
    type: byte
    vector: payload_A
  states: {}
- name: txA_modulador
  id: digital_constellation_modulator
  parameters:
    comment: |-
      Modulador 4-QAM: toma los bytes de a 2 bits,
      aplica la codificación diferencial (la
      información va en el cambio de fase entre
      símbolos) y forma cada pulso con un filtro RRC
      (roll-off 0,35).
      Entra: bytes (8 bits cada uno).
      Sale: complejos (I + jQ), 4 muestras por
        símbolo (mientras tiene el turno).
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: txA_trama
  id: blocks_tagged_stream_mux
  parameters:
    comment: |-
      Pone el encabezado delante del
      payload: arma la trama
      completa.
      Entra: in0 = encabezado (12
        bytes), in1 = payload + CRC
        (L_A + 4 bytes).
      Sale: bytes: trama de L_A + 16
        bytes (packet_len).
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: txA_vs
  id: virtual_sink
  parameters:
    comment: |-
      Conexión sin cable: la señal del nodo A sigue
      en los Virtual Source "tx_A" (canal compartido
      y gráficos).
      Entra: complejos.
      Sale: nada a la vista.
    stream_id: tx_A
  states: {}
- name: txB_a_paquetes
  id: blocks_stream_to_tagged_stream
  parameters:
    comment: |-
      Corta el flujo en grupos de L_B
      bytes (uno por trama) y marca el
      comienzo de cada grupo con la
      etiqueta packet_len. Así los bloques
      siguientes saben dónde empieza y
      termina cada trama.
      Entra: bytes sin marcas.
      Sale: los mismos bytes, en grupos de
        L_B marcados con packet_len.
    len_tag_key: '"packet_len"'
    packet_len: L_B
    type: byte
  states: {}
- name: txB_crc
  id: digital_crc32_bb
  parameters:
    check: 'False'
    comment: |-
      Calcula el CRC-32 de cada payload y se lo
      agrega al final (4 bytes). El receptor lo
      vuelve a calcular para descartar las tramas
      con errores.
      Entra: bytes: payload de L_B bytes
        (packet_len).
      Sale: bytes: payload + CRC = L_B + 4 bytes.
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: txB_encabezado
  id: digital_protocol_formatter_bb
  parameters:
    comment: |-
      Arma el encabezado de cada trama
      con el formato "formato_trama":
      preámbulo de 64 bits + longitud (2
      veces). Solo produce el
      encabezado, no copia el payload.
      Entra: bytes: payload + CRC
        (packet_len).
      Sale: bytes: encabezado de 12
        bytes (packet_len = 12).
    format: formato_trama
    len_tag_key: '"packet_len"'
  states: {}
- name: txB_fuente
  id: blocks_vector_source_x
  parameters:
    comment: |-
      Entrega una y otra vez el mensaje del nodo B
      (lista "payload_B").
      Entra: nada (es una fuente).
      Sale: bytes del mensaje.
    repeat: 'True'
    type: byte
    vector: payload_B
  states: {}
- name: txB_modulador
  id: digital_constellation_modulator
  parameters:
    comment: |-
      Modulador 4-QAM: toma los bytes de a 2 bits,
      aplica la codificación diferencial (la
      información va en el cambio de fase entre
      símbolos) y forma cada pulso con un filtro RRC
      (roll-off 0,35).
      Entra: bytes (8 bits cada uno).
      Sale: complejos (I + jQ), 4 muestras por
        símbolo (mientras tiene el turno).
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: txB_trama
  id: blocks_tagged_stream_mux
  parameters:
    comment: |-
      Pone el encabezado delante del
      payload: arma la trama
      completa.
      Entra: in0 = encabezado (12
        bytes), in1 = payload + CRC
        (L_B + 4 bytes).
      Sale: bytes: trama de L_B + 16
        bytes (packet_len).
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: txB_vs
  id: virtual_sink
  parameters:
    comment: |-
      Conexión sin cable: la señal del nodo B sigue
      en los Virtual Source "tx_B" (canal compartido
      y gráficos).
      Entra: complejos.
      Sale: nada a la vista.
    stream_id: tx_B
  states: {}

connections:
- [canal_tx_A, '0', turnos, '0']
- [canal_tx_B, '0', turnos, '2']
- [conmutador_rx, '0', osc_rxB, '0']
- [conmutador_rx, '1', guarda_1, '0']
- [conmutador_rx, '2', osc_rxA, '0']
- [conmutador_rx, '3', guarda_3, '0']
- [fase, '0', suma_ruido, '0']
- [limite, '0', fase, '0']
- [osc_rxA, '0', rxA_vs_entrada, '0']
- [osc_rxB, '0', rxB_vs_entrada, '0']
- [ruido_awgn, '0', suma_ruido, '1']
- [rxA_a_bits, '0', rxA_detector_trama, '0']
- [rxA_a_bits, '0', rxA_marca_preambulo, '0']
- [rxA_a_bytes, '0', rxA_crc, '0']
- [rxA_a_pdu, pdus, rxA_mensajes, store]
- [rxA_alinear, '0', rxA_rx_descartar, '0']
- [rxA_costas, '0', rxA_decisor, '0']
- [rxA_crc, '0', rxA_a_pdu, '0']
- [rxA_dec_diferencial, '0', rxA_mapa_gray, '0']
- [rxA_decisor, '0', rxA_dec_diferencial, '0']
- [rxA_detector_trama, '0', rxA_a_bytes, '0']
- [rxA_entrada, '0', rxA_filtro_adaptado, '0']
- [rxA_filtro_adaptado, '0', rxA_sinc_simbolo, '0']
- [rxA_mapa_gray, '0', rxA_a_bits, '0']
- [rxA_marca_preambulo, '0', rxA_alinear, '0']
- [rxA_medidor_ber, '0', rxA_sonda_ber, '0']
- [rxA_ref_a_paquetes, '0', rxA_ref_crc, '0']
- [rxA_ref_bits, '0', rxA_ref_saltar_preambulo, '0']
- [rxA_ref_bytes, '0', rxA_medidor_ber, '1']
- [rxA_ref_crc, '0', rxA_ref_encabezado, '0']
- [rxA_ref_crc, '0', rxA_ref_trama, '1']
- [rxA_ref_descartar, '0', rxA_ref_bytes, '0']
- [rxA_ref_encabezado, '0', rxA_ref_trama, '0']
- [rxA_ref_fuente, '0', rxA_ref_a_paquetes, '0']
- [rxA_ref_saltar_preambulo, '0', rxA_ref_descartar, '0']
- [rxA_ref_trama, '0', rxA_ref_bits, '0']
- [rxA_rx_bytes, '0', rxA_medidor_ber, '0']
- [rxA_rx_descartar, '0', rxA_rx_bytes, '0']
- [rxA_sinc_simbolo, '0', rxA_costas, '0']
- [rxA_sinc_simbolo, '1', rxA_sinc_null_1, '0']
- [rxA_sinc_simbolo, '2', rxA_sinc_null_2, '0']
- [rxA_sinc_simbolo, '3', rxA_sinc_null_3, '0']
- [rxB_a_bits, '0', rxB_detector_trama, '0']
- [rxB_a_bits, '0', rxB_marca_preambulo, '0']
- [rxB_a_bytes, '0', rxB_crc, '0']
- [rxB_a_pdu, pdus, rxB_mensajes, store]
- [rxB_alinear, '0', rxB_rx_descartar, '0']
- [rxB_costas, '0', rxB_decisor, '0']
- [rxB_crc, '0', rxB_a_pdu, '0']
- [rxB_dec_diferencial, '0', rxB_mapa_gray, '0']
- [rxB_decisor, '0', rxB_dec_diferencial, '0']
- [rxB_detector_trama, '0', rxB_a_bytes, '0']
- [rxB_entrada, '0', rxB_filtro_adaptado, '0']
- [rxB_filtro_adaptado, '0', rxB_sinc_simbolo, '0']
- [rxB_mapa_gray, '0', rxB_a_bits, '0']
- [rxB_marca_preambulo, '0', rxB_alinear, '0']
- [rxB_medidor_ber, '0', rxB_sonda_ber, '0']
- [rxB_ref_a_paquetes, '0', rxB_ref_crc, '0']
- [rxB_ref_bits, '0', rxB_ref_saltar_preambulo, '0']
- [rxB_ref_bytes, '0', rxB_medidor_ber, '1']
- [rxB_ref_crc, '0', rxB_ref_encabezado, '0']
- [rxB_ref_crc, '0', rxB_ref_trama, '1']
- [rxB_ref_descartar, '0', rxB_ref_bytes, '0']
- [rxB_ref_encabezado, '0', rxB_ref_trama, '0']
- [rxB_ref_fuente, '0', rxB_ref_a_paquetes, '0']
- [rxB_ref_saltar_preambulo, '0', rxB_ref_descartar, '0']
- [rxB_ref_trama, '0', rxB_ref_bits, '0']
- [rxB_rx_bytes, '0', rxB_medidor_ber, '0']
- [rxB_rx_descartar, '0', rxB_rx_bytes, '0']
- [rxB_sinc_simbolo, '0', rxB_costas, '0']
- [rxB_sinc_simbolo, '1', rxB_sinc_null_1, '0']
- [rxB_sinc_simbolo, '2', rxB_sinc_null_2, '0']
- [rxB_sinc_simbolo, '3', rxB_sinc_null_3, '0']
- [silencio_1, '0', turnos, '1']
- [silencio_3, '0', turnos, '3']
- [suma_ruido, '0', conmutador_rx, '0']
- [turnos, '0', limite, '0']
- [txA_a_paquetes, '0', txA_crc, '0']
- [txA_crc, '0', txA_encabezado, '0']
- [txA_crc, '0', txA_trama, '1']
- [txA_encabezado, '0', txA_trama, '0']
- [txA_fuente, '0', txA_a_paquetes, '0']
- [txA_modulador, '0', txA_vs, '0']
- [txA_trama, '0', txA_modulador, '0']
- [txB_a_paquetes, '0', txB_crc, '0']
- [txB_crc, '0', txB_encabezado, '0']
- [txB_crc, '0', txB_trama, '1']
- [txB_encabezado, '0', txB_trama, '0']
- [txB_fuente, '0', txB_a_paquetes, '0']
- [txB_modulador, '0', txB_vs, '0']
- [txB_trama, '0', txB_modulador, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
