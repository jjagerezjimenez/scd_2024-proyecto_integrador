options:
  parameters:
    author: Juan Gerez Jimenez
    generate_options: qt_gui
    id: v2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: costas_loop_bw
  id: variable
  parameters:
    value: '0.0001'
  states: {}
- name: epsilon
  id: variable
  parameters:
    value: '1.0'
  states: {}
- name: fll_loop_bw
  id: variable
  parameters:
    value: '0.01'
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: '0.001'
  states: {}
- name: noise_volt
  id: variable
  parameters:
    value: '0.01'
  states: {}
- name: pfb_loop_bw
  id: variable
  parameters:
    value: '0.01'
  states: {}
- name: qpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: samp_rate/sps
  states: {}
- name: taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: alpha
    gain: '1'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: symbol_rate
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: int
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: epsilon
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: taps
  states: {}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: qpsk
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: costas_loop_bw
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_crc32_bb_1
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '32'
    rolloff: alpha
    samps_per_sym: sps
    type: cc
    w: fll_loop_bw
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: '32'
    init_phase: '0'
    loop_bw: pfb_loop_bw
    max_dev: '1.0'
    osps: '1'
    sps: sps
    taps: taps
    type: ccf
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: digital.header_format_default("1010101111001101", 1, 2)
    len_tag_key: '"packet_len"'
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    gain: '1'
    interp: sps
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: symbol_rate
    type: interp_fir_filter_ccf
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: entrada_rx
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: transmisor
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: transmisor
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: entrada_rx
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: entrada_rx
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: transmisor
  states: {}

connections:
- [blocks_throttle2_0, '0', virtual_sink_1, '0']
- [channels_channel_model_0, '0', virtual_sink_0, '0']
- [digital_constellation_encoder_bc_0, '0', root_raised_cosine_filter_0, '0']
- [digital_costas_loop_cc_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [digital_crc32_bb_0, '0', digital_constellation_encoder_bc_0, '0']
- [digital_fll_band_edge_cc_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_protocol_formatter_bb_0, '0', digital_crc32_bb_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, digital_crc32_bb_1, '0']
- [root_raised_cosine_filter_0, '0', blocks_throttle2_0, '0']
- [virtual_source_0, '0', digital_fll_band_edge_cc_0, '0']
- [virtual_source_1, '0', channels_channel_model_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
