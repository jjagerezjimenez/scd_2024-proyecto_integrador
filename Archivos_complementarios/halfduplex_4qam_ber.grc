options:
  parameters:
    author: Juan Gerez
    description: El mismo enlace half-duplex de halfduplex_4qam.grc, sin gráficos, para medir BER por línea de comandos
    generate_options: no_gui
    id: halfduplex_4qam_ber
    output_language: python
    run_options: run
    title: Medición de BER del enlace half-duplex 4-QAM (sin interfaz)
  states: {}

blocks:
- name: imports
  id: import
  parameters:
    imports: import math, cmath
  states: {}
- name: ebn0_db
  id: parameter
  parameters:
    label: Eb/N0 [dB]
    type: eng_float
    value: '6.0'
  states: {}
- name: fase_deg
  id: parameter
  parameters:
    label: Fase del canal [grados]
    type: eng_float
    value: '0.0'
  states: {}
- name: cfo_hz
  id: parameter
  parameters:
    label: Desvio entre osciladores A-B [Hz]
    type: eng_float
    value: '0.0'
  states: {}
- name: costas_bw
  id: parameter
  parameters:
    label: BW del lazo de Costas (0 = sin corregir fase)
    type: eng_float
    value: '0.005'
  states: {}
- name: sync_bw
  id: parameter
  parameters:
    label: BW del sincronismo de simbolo
    type: eng_float
    value: '0.01'
  states: {}
- name: muestras
  id: parameter
  parameters:
    label: Muestras del canal compartido
    type: intx
    value: '4000000'
  states: {}
- name: semilla
  id: parameter
  parameters:
    label: Semilla del ruido
    type: intx
    value: '1'
  states: {}
- name: descartar
  id: parameter
  parameters:
    label: Bits descartados al inicio (enganche de los lazos)
    type: intx
    value: '100000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Frecuencia de muestreo [muestras/s]
    value: '500000'
  states: {}
- name: sps
  id: variable
  parameters:
    comment: Muestras por símbolo
    value: '4'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    comment: Factor de roll-off del filtro RRC
    value: '0.35'
  states: {}
- name: ranura
  id: variable
  parameters:
    comment: Muestras de cada turno de transmisión (múltiplo de sps)
    value: '2048'
  states: {}
- name: guarda
  id: variable
  parameters:
    comment: Muestras de silencio entre turnos
    value: '256'
  states: {}
- name: mensaje_A
  id: variable
  parameters:
    comment: Texto que transmite el nodo A
    value: '"Hola, soy el nodo A. Este mensaje viaja por el canal compartido en mi ranura de tiempo (TDD)."'
  states: {}
- name: mensaje_B
  id: variable
  parameters:
    comment: Texto que transmite el nodo B
    value: '"Hola, soy el nodo B. Respondo en la otra ranura: nunca transmitimos los dos al mismo tiempo!!"'
  states: {}
- name: payload_A
  id: variable
  parameters:
    value: list(mensaje_A.encode())
  states: {}
- name: payload_B
  id: variable
  parameters:
    value: list(mensaje_B.encode())
  states: {}
- name: L_A
  id: variable
  parameters:
    value: len(payload_A)
  states: {}
- name: L_B
  id: variable
  parameters:
    value: len(payload_B)
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[-0.707-0.707j, 0.707-0.707j, +0.707+0.707j, -0.707+0.707j]'
    sym_map: '[0, 1, 3, 2]'
    rot_sym: '4'
    real_sect: '2'
    imag_sect: '2'
    w_real_sect: '1'
    w_imag_sect: '1'
  states: {}
- name: formato_trama
  id: variable_header_format_default
  parameters:
    access_code: '0'
    threshold: '0'
    bps: '1'
  states: {}
- name: umbral
  id: variable
  parameters:
    comment: Bits erróneos tolerados al buscar el preámbulo de 64 bits
    value: '12'
  states: {}
- name: ruido
  id: variable
  parameters:
    comment: 'Desvío del ruido complejo: potencia de señal = 1 por muestra, Es/N0 = 2 Eb/N0'
    value: math.sqrt(sps / (2 * 10**(ebn0_db / 10)))
  states: {}
- name: nota_tx
  id: note
  parameters:
    note: TRANSMISORES de los nodos A y B (igual que halfduplex_4qam.grc)
  states: {}
- name: txA_fuente
  id: blocks_vector_source_x
  parameters:
    type: byte
    vector: payload_A
    repeat: 'True'
  states: {}
- name: txA_a_paquetes
  id: blocks_stream_to_tagged_stream
  parameters:
    type: byte
    packet_len: L_A
    len_tag_key: '"packet_len"'
  states: {}
- name: txA_crc
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: txA_encabezado
  id: digital_protocol_formatter_bb
  parameters:
    format: formato_trama
    len_tag_key: '"packet_len"'
  states: {}
- name: txA_trama
  id: blocks_tagged_stream_mux
  parameters:
    type: byte
    ninputs: '2'
    lengthtagname: '"packet_len"'
  states: {}
- name: txA_modulador
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    samples_per_symbol: sps
    excess_bw: excess_bw
  states: {}
- name: txA_vs
  id: virtual_sink
  parameters:
    stream_id: tx_A
  states: {}
- name: txB_fuente
  id: blocks_vector_source_x
  parameters:
    type: byte
    vector: payload_B
    repeat: 'True'
  states: {}
- name: txB_a_paquetes
  id: blocks_stream_to_tagged_stream
  parameters:
    type: byte
    packet_len: L_B
    len_tag_key: '"packet_len"'
  states: {}
- name: txB_crc
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: txB_encabezado
  id: digital_protocol_formatter_bb
  parameters:
    format: formato_trama
    len_tag_key: '"packet_len"'
  states: {}
- name: txB_trama
  id: blocks_tagged_stream_mux
  parameters:
    type: byte
    ninputs: '2'
    lengthtagname: '"packet_len"'
  states: {}
- name: txB_modulador
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    samples_per_symbol: sps
    excess_bw: excess_bw
  states: {}
- name: txB_vs
  id: virtual_sink
  parameters:
    stream_id: tx_B
  states: {}
- name: nota_tdd
  id: note
  parameters:
    note: 'CANAL COMPARTIDO (TDD): Stream Mux = turnos [A | guarda | B | guarda]; Head limita la cantidad de muestras y hace que el flowgraph termine solo; Stream Demux = conmutador de recepción.'
  states: {}
- name: canal_tx_A
  id: virtual_source
  parameters:
    stream_id: tx_A
  states: {}
- name: canal_tx_B
  id: virtual_source
  parameters:
    stream_id: tx_B
  states: {}
- name: silencio_1
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: silencio_3
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: turnos
  id: blocks_stream_mux
  parameters:
    type: complex
    lengths: '[ranura, guarda, ranura, guarda]'
    num_inputs: '4'
  states: {}
- name: limite
  id: blocks_head
  parameters:
    type: complex
    num_items: muestras
  states: {}
- name: fase
  id: blocks_multiply_const_vxx
  parameters:
    type: complex
    const: cmath.exp(1j * math.radians(fase_deg))
  states: {}
- name: ruido_awgn
  id: analog_noise_source_x
  parameters:
    type: complex
    noise_type: analog.GR_GAUSSIAN
    amp: ruido
    seed: semilla
  states: {}
- name: suma_ruido
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: conmutador_rx
  id: blocks_stream_demux
  parameters:
    type: complex
    lengths: '[ranura, guarda, ranura, guarda]'
    num_outputs: '4'
  states: {}
- name: guarda_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: guarda_3
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: osc_rxB
  id: blocks_rotator_cc
  parameters:
    phase_inc: 2 * math.pi * cfo_hz / samp_rate
  states: {}
- name: osc_rxA
  id: blocks_rotator_cc
  parameters:
    phase_inc: '-2 * math.pi * cfo_hz / samp_rate'
  states: {}
- name: rxB_vs_entrada
  id: virtual_sink
  parameters:
    stream_id: entrada_rx_B
  states: {}
- name: rxA_vs_entrada
  id: virtual_sink
  parameters:
    stream_id: entrada_rx_A
  states: {}
- name: rxA_nota
  id: note
  parameters:
    note: 'RECEPTOR DEL NODO A (recibe lo que transmite B): resultados en rxA_medidor_ber (errores y BER) y rxA_mensajes (tramas con CRC correcto)'
  states: {}
- name: rxA_entrada
  id: virtual_source
  parameters:
    stream_id: entrada_rx_A
  states: {}
- name: rxA_filtro_adaptado
  id: filter_fft_rrc_filter
  parameters:
    type: ccc
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    alpha: excess_bw
    ntaps: 11*sps
  states: {}
- name: rxA_sinc_simbolo
  id: digital_symbol_sync_xx
  parameters:
    type: cc
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    sps: sps
    ted_gain: '1.0'
    loop_bw: sync_bw
    damping: '1.0'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
  states: {}
- name: rxA_costas
  id: digital_costas_loop_cc
  parameters:
    w: costas_bw
    order: '4'
  states: {}
- name: rxA_decisor
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: rxA_dec_diferencial
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: rxA_mapa_gray
  id: digital_map_bb
  parameters:
    map: '[0, 1, 3, 2]'
  states: {}
- name: rxA_a_bits
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: rxA_detector_trama
  id: digital_correlate_access_code_xx_ts
  parameters:
    minoutbuf: '600000'
    type: byte
    access_code: digital.packet_utils.default_access_code
    threshold: umbral
    tagname: '"packet_len"'
  states: {}
- name: rxA_a_bytes
  id: blocks_repack_bits_bb
  parameters:
    minoutbuf: '70000'
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
  states: {}
- name: rxA_crc
  id: digital_crc32_bb
  parameters:
    minoutbuf: '70000'
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: rxA_a_pdu
  id: pdu_tagged_stream_to_pdu
  parameters:
    type: byte
    tag: '"packet_len"'
  states: {}
- name: rxA_mensajes
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: rxA_marca_preambulo
  id: digital_correlate_access_code_tag_xx
  parameters:
    type: byte
    access_code: digital.packet_utils.default_access_code
    threshold: umbral
    tagname: '"inicio_trama"'
  states: {}
- name: rxA_alinear
  id: blocks_tagged_stream_align
  parameters:
    type: byte
    lengthtagname: '"inicio_trama"'
  states: {}
- name: rxA_ref_fuente
  id: blocks_vector_source_x
  parameters:
    type: byte
    vector: payload_B
    repeat: 'True'
  states: {}
- name: rxA_ref_a_paquetes
  id: blocks_stream_to_tagged_stream
  parameters:
    type: byte
    packet_len: L_B
    len_tag_key: '"packet_len"'
  states: {}
- name: rxA_ref_crc
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: rxA_ref_encabezado
  id: digital_protocol_formatter_bb
  parameters:
    format: formato_trama
    len_tag_key: '"packet_len"'
  states: {}
- name: rxA_ref_trama
  id: blocks_tagged_stream_mux
  parameters:
    type: byte
    ninputs: '2'
    lengthtagname: '"packet_len"'
  states: {}
- name: rxA_ref_bits
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: rxA_ref_saltar_preambulo
  id: blocks_skiphead
  parameters:
    type: byte
    num_items: '64'
  states: {}
- name: rxA_rx_bytes
  id: blocks_repack_bits_bb
  parameters:
    k: '1'
    l: '8'
    endianness: gr.GR_MSB_FIRST
  states: {}
- name: rxA_ref_bytes
  id: blocks_repack_bits_bb
  parameters:
    k: '1'
    l: '8'
    endianness: gr.GR_MSB_FIRST
  states: {}
- name: rxA_medidor_ber
  id: fec_ber_bf
  parameters:
    test_mode: 'False'
  states: {}
- name: rxA_sonda_ber
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: rxA_rx_descartar
  id: blocks_skiphead
  parameters:
    type: byte
    num_items: descartar
  states: {}
- name: rxA_ref_descartar
  id: blocks_skiphead
  parameters:
    type: byte
    num_items: descartar
  states: {}
- name: rxA_sinc_null_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: rxA_sinc_null_2
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: rxA_sinc_null_3
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: rxB_nota
  id: note
  parameters:
    note: 'RECEPTOR DEL NODO B (recibe lo que transmite A): resultados en rxB_medidor_ber (errores y BER) y rxB_mensajes (tramas con CRC correcto)'
  states: {}
- name: rxB_entrada
  id: virtual_source
  parameters:
    stream_id: entrada_rx_B
  states: {}
- name: rxB_filtro_adaptado
  id: filter_fft_rrc_filter
  parameters:
    type: ccc
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    alpha: excess_bw
    ntaps: 11*sps
  states: {}
- name: rxB_sinc_simbolo
  id: digital_symbol_sync_xx
  parameters:
    type: cc
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    sps: sps
    ted_gain: '1.0'
    loop_bw: sync_bw
    damping: '1.0'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
  states: {}
- name: rxB_costas
  id: digital_costas_loop_cc
  parameters:
    w: costas_bw
    order: '4'
  states: {}
- name: rxB_decisor
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: rxB_dec_diferencial
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: rxB_mapa_gray
  id: digital_map_bb
  parameters:
    map: '[0, 1, 3, 2]'
  states: {}
- name: rxB_a_bits
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: rxB_detector_trama
  id: digital_correlate_access_code_xx_ts
  parameters:
    minoutbuf: '600000'
    type: byte
    access_code: digital.packet_utils.default_access_code
    threshold: umbral
    tagname: '"packet_len"'
  states: {}
- name: rxB_a_bytes
  id: blocks_repack_bits_bb
  parameters:
    minoutbuf: '70000'
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
  states: {}
- name: rxB_crc
  id: digital_crc32_bb
  parameters:
    minoutbuf: '70000'
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: rxB_a_pdu
  id: pdu_tagged_stream_to_pdu
  parameters:
    type: byte
    tag: '"packet_len"'
  states: {}
- name: rxB_mensajes
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: rxB_marca_preambulo
  id: digital_correlate_access_code_tag_xx
  parameters:
    type: byte
    access_code: digital.packet_utils.default_access_code
    threshold: umbral
    tagname: '"inicio_trama"'
  states: {}
- name: rxB_alinear
  id: blocks_tagged_stream_align
  parameters:
    type: byte
    lengthtagname: '"inicio_trama"'
  states: {}
- name: rxB_ref_fuente
  id: blocks_vector_source_x
  parameters:
    type: byte
    vector: payload_A
    repeat: 'True'
  states: {}
- name: rxB_ref_a_paquetes
  id: blocks_stream_to_tagged_stream
  parameters:
    type: byte
    packet_len: L_A
    len_tag_key: '"packet_len"'
  states: {}
- name: rxB_ref_crc
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: rxB_ref_encabezado
  id: digital_protocol_formatter_bb
  parameters:
    format: formato_trama
    len_tag_key: '"packet_len"'
  states: {}
- name: rxB_ref_trama
  id: blocks_tagged_stream_mux
  parameters:
    type: byte
    ninputs: '2'
    lengthtagname: '"packet_len"'
  states: {}
- name: rxB_ref_bits
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: rxB_ref_saltar_preambulo
  id: blocks_skiphead
  parameters:
    type: byte
    num_items: '64'
  states: {}
- name: rxB_rx_bytes
  id: blocks_repack_bits_bb
  parameters:
    k: '1'
    l: '8'
    endianness: gr.GR_MSB_FIRST
  states: {}
- name: rxB_ref_bytes
  id: blocks_repack_bits_bb
  parameters:
    k: '1'
    l: '8'
    endianness: gr.GR_MSB_FIRST
  states: {}
- name: rxB_medidor_ber
  id: fec_ber_bf
  parameters:
    test_mode: 'False'
  states: {}
- name: rxB_sonda_ber
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: rxB_rx_descartar
  id: blocks_skiphead
  parameters:
    type: byte
    num_items: descartar
  states: {}
- name: rxB_ref_descartar
  id: blocks_skiphead
  parameters:
    type: byte
    num_items: descartar
  states: {}
- name: rxB_sinc_null_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: rxB_sinc_null_2
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: rxB_sinc_null_3
  id: blocks_null_sink
  parameters:
    type: float
  states: {}

connections:
- [txA_fuente, '0', txA_a_paquetes, '0']
- [txA_a_paquetes, '0', txA_crc, '0']
- [txA_crc, '0', txA_encabezado, '0']
- [txA_crc, '0', txA_trama, '1']
- [txA_encabezado, '0', txA_trama, '0']
- [txA_trama, '0', txA_modulador, '0']
- [txA_modulador, '0', txA_vs, '0']
- [txB_fuente, '0', txB_a_paquetes, '0']
- [txB_a_paquetes, '0', txB_crc, '0']
- [txB_crc, '0', txB_encabezado, '0']
- [txB_crc, '0', txB_trama, '1']
- [txB_encabezado, '0', txB_trama, '0']
- [txB_trama, '0', txB_modulador, '0']
- [txB_modulador, '0', txB_vs, '0']
- [canal_tx_A, '0', turnos, '0']
- [silencio_1, '0', turnos, '1']
- [canal_tx_B, '0', turnos, '2']
- [silencio_3, '0', turnos, '3']
- [turnos, '0', limite, '0']
- [limite, '0', fase, '0']
- [fase, '0', suma_ruido, '0']
- [ruido_awgn, '0', suma_ruido, '1']
- [suma_ruido, '0', conmutador_rx, '0']
- [conmutador_rx, '1', guarda_1, '0']
- [conmutador_rx, '3', guarda_3, '0']
- [conmutador_rx, '0', osc_rxB, '0']
- [conmutador_rx, '2', osc_rxA, '0']
- [osc_rxB, '0', rxB_vs_entrada, '0']
- [osc_rxA, '0', rxA_vs_entrada, '0']
- [rxA_entrada, '0', rxA_filtro_adaptado, '0']
- [rxA_filtro_adaptado, '0', rxA_sinc_simbolo, '0']
- [rxA_sinc_simbolo, '0', rxA_costas, '0']
- [rxA_costas, '0', rxA_decisor, '0']
- [rxA_decisor, '0', rxA_dec_diferencial, '0']
- [rxA_dec_diferencial, '0', rxA_mapa_gray, '0']
- [rxA_mapa_gray, '0', rxA_a_bits, '0']
- [rxA_a_bits, '0', rxA_detector_trama, '0']
- [rxA_detector_trama, '0', rxA_a_bytes, '0']
- [rxA_a_bytes, '0', rxA_crc, '0']
- [rxA_crc, '0', rxA_a_pdu, '0']
- [rxA_a_pdu, pdus, rxA_mensajes, store]
- [rxA_a_bits, '0', rxA_marca_preambulo, '0']
- [rxA_marca_preambulo, '0', rxA_alinear, '0']
- [rxA_ref_fuente, '0', rxA_ref_a_paquetes, '0']
- [rxA_ref_a_paquetes, '0', rxA_ref_crc, '0']
- [rxA_ref_crc, '0', rxA_ref_encabezado, '0']
- [rxA_ref_crc, '0', rxA_ref_trama, '1']
- [rxA_ref_encabezado, '0', rxA_ref_trama, '0']
- [rxA_ref_trama, '0', rxA_ref_bits, '0']
- [rxA_ref_bits, '0', rxA_ref_saltar_preambulo, '0']
- [rxA_alinear, '0', rxA_rx_descartar, '0']
- [rxA_rx_descartar, '0', rxA_rx_bytes, '0']
- [rxA_ref_saltar_preambulo, '0', rxA_ref_descartar, '0']
- [rxA_ref_descartar, '0', rxA_ref_bytes, '0']
- [rxA_rx_bytes, '0', rxA_medidor_ber, '0']
- [rxA_ref_bytes, '0', rxA_medidor_ber, '1']
- [rxA_medidor_ber, '0', rxA_sonda_ber, '0']
- [rxA_sinc_simbolo, '1', rxA_sinc_null_1, '0']
- [rxA_sinc_simbolo, '2', rxA_sinc_null_2, '0']
- [rxA_sinc_simbolo, '3', rxA_sinc_null_3, '0']
- [rxB_entrada, '0', rxB_filtro_adaptado, '0']
- [rxB_filtro_adaptado, '0', rxB_sinc_simbolo, '0']
- [rxB_sinc_simbolo, '0', rxB_costas, '0']
- [rxB_costas, '0', rxB_decisor, '0']
- [rxB_decisor, '0', rxB_dec_diferencial, '0']
- [rxB_dec_diferencial, '0', rxB_mapa_gray, '0']
- [rxB_mapa_gray, '0', rxB_a_bits, '0']
- [rxB_a_bits, '0', rxB_detector_trama, '0']
- [rxB_detector_trama, '0', rxB_a_bytes, '0']
- [rxB_a_bytes, '0', rxB_crc, '0']
- [rxB_crc, '0', rxB_a_pdu, '0']
- [rxB_a_pdu, pdus, rxB_mensajes, store]
- [rxB_a_bits, '0', rxB_marca_preambulo, '0']
- [rxB_marca_preambulo, '0', rxB_alinear, '0']
- [rxB_ref_fuente, '0', rxB_ref_a_paquetes, '0']
- [rxB_ref_a_paquetes, '0', rxB_ref_crc, '0']
- [rxB_ref_crc, '0', rxB_ref_encabezado, '0']
- [rxB_ref_crc, '0', rxB_ref_trama, '1']
- [rxB_ref_encabezado, '0', rxB_ref_trama, '0']
- [rxB_ref_trama, '0', rxB_ref_bits, '0']
- [rxB_ref_bits, '0', rxB_ref_saltar_preambulo, '0']
- [rxB_alinear, '0', rxB_rx_descartar, '0']
- [rxB_rx_descartar, '0', rxB_rx_bytes, '0']
- [rxB_ref_saltar_preambulo, '0', rxB_ref_descartar, '0']
- [rxB_ref_descartar, '0', rxB_ref_bytes, '0']
- [rxB_rx_bytes, '0', rxB_medidor_ber, '0']
- [rxB_ref_bytes, '0', rxB_medidor_ber, '1']
- [rxB_medidor_ber, '0', rxB_sonda_ber, '0']
- [rxB_sinc_simbolo, '1', rxB_sinc_null_1, '0']
- [rxB_sinc_simbolo, '2', rxB_sinc_null_2, '0']
- [rxB_sinc_simbolo, '3', rxB_sinc_null_3, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
